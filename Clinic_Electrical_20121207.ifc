Properties of the parts of a building model (IFC2X3), part 3 of 7

# IfcEnergyConversionDevice: 914mmx673mm (2)
Name (M_Transformer Switchboard:914mmx673mm:...) | Appliance - Dwelling Unit Estimated Demand Current = Appliance - Dwelling Unit Connected Current | Apparent Load Phase A | Total Estimated Demand | Appliance - Dwelling Unit Estimated Demand = Appliance - Dwelling Unit Connected | Total Estimated Demand Current | Total Connected Current | Current Phase A | Current Phase B | Apparent Load Phase B | Current Phase C | Apparent Load Phase C | Total Demand Factor | Total Connected | Distribution System | Panel Name | Mark
MS1:860947 | 0.651925 | 333975 | 1001926 | 5834.04 | 111.96 | 111.96 | 112.012 | 112.012 | 333975 | 112.012 | 333975 | 1 | 1001926 | Distribution System: 480/277 Wye | MS1 | 12 | Electrical - Loads - Cooling Estimated Demand: 996092; Cooling Connected Current: 111.308; Cooling Connected: 996092; Cooling Demand Factor: 1; Cooling Estimated Demand Current: 111.308
MS2:861040 | 12.4908 | 993638 | 1299187 | 48437.6 | 335.025 | 673.124 | 773.762 | 643.975 | 825997 | 610.259 | 788253 | 0.497717 | 2610291 | Distribution System: 120/208 Wye | MS2 | 13 | Electrical - Loads - Lighting - Dwelling Unit Demand Factor: 0.379989; Receptacle Estimated Demand: 984790; Lighting - Dwelling Unit Connected: 699913; Receptacle Demand Factor: 0.528905; Lighting - Dwelling Unit Estimated Demand Current: 68.5837; Lighting - Dwelling Unit Connected Current: 180.489; Other Estimated Demand Current: 0; Other Connected Current: 0; Receptacle Estimated Demand Current: 253.951; Other Connected: 0; Receptacle Connected: 1861941; Lighting - Dwelling Unit Estimated Demand: 265959; Receptacle Connected Current: 480.144; Other Estimated Demand: 0

# IfcFlowMovingDevice: 3.9 LPS - 0.8 Meter Head, M_Inline Pump - Circulator:3.9 LPS - 0.8 Meter Head:3.9 LPS - 0.8 Meter Head:1060890
In: 1D18
Type - ElementType: 3.9 LPS - 0.8 Meter Head; PredefinedType: CIRCULATOR; Classification:  (UniFormat)
Electrical - Loads - Apparent Load: 5834.04; Panel: MS1; Circuit Number: 2
Electrical - Voltage: 4951.4; Load Classification: Appliance - Dwelling Unit; Number of Poles: 3
Dimensions - Discharge Nominal Radius: 0.0656168; Suction Nominal Radius: 0.0656168; Flange Height: 0.13 m; Suction Outside Diameter: 0.172244; Length 1: 0.431 m; Housing Width: 0.152 m; Outside Diameter 1: 0.184 m; Length 2: 0.3448 m; Discharge Nominal Diameter: 0.131234; Suction Outside Radius: 0.086122; Suction Nominal Diameter: 0.131234; Length 3: 0.062064 m; Flange Diameter: 0.102 m; Outside Diameter 2: 0.171 m; Outside Diameter 4: 0.062064 m
Identity Data - OmniClass Title: Pumps; OmniClass Number: 23.60.30.21; Manufacturer: N/A; Mark: HWP-1
Other - WarrantyDescription: N/A; Shape: N/A; Radius 1: 0.07915 m; NominalHeight: 0; ReplacementCost: N/A; ExpectedLife: N/A; Features: N/A; WarrantyDurationLabor: N/A; WarrantyGuarantorLabor: N/A; PowerFactor: 0; Flange Radius: 0.051 m; WarrantyDurationParts: N/A; HasProtectiveEarth: TRUE; Size: 0; Radius 3: 0.056432 m; ConductorFunction: L1; NominalWidth: 0; AccessibilityPerformance: N/A; Outside Radius 2: 0.0855 m; RatedCurrent: 0; IP_Code: 0; NominalLength: 0; Length 4: 0.0213482 m; WarrantyGuarantorParts: N/A; ModelLabel: N/A; Grade: N/A; SustainabilityPerformance: N/A; ProductionYear: N/A; Radius 2: 0.0728 m; Material: N/A; NumberOfPoles: 0; NominalFrequencyRange: 0; ModelReference: N/A; Constituents: N/A; CodePerformance: N/A; AssetAccountingType: FIXED; RatedVoltage: 0; Outside Radius 1: 0.092 m; Outside Radius 4: 0.031032 m; InstallationDate: N/A; WarrantyStartDate: N/A; BarCode: N/A; AssetIdentifier: N/A; TagNumber: N/A; SerialNumber: N/A
Mechanical - System Name: Domestic Hot Water 1; System Classification: Undefined,Power; RPM: 1450
Constraints - Host: Level : Level 2; Level: Level: Level 2; Offset: -1.4 m
Phasing - Phase Created: New Construction

# IfcFlowMovingDevice: 63300000 J (2)
In: 2D05
Type - ElementType: 63300000 J; PredefinedType: CENTRIFUGALAIRFOIL; Classification:  (UniFormat)
Phasing - Phase Created: New Construction
Mechanical - Flow - Return Airflow: 12.7486; Supply Airflow: 12.7486
Electrical - Loads - Circuit Number: 1,3,5; Apparent Load: 11194.5
Other - SerialNumber: N/A; InstallationDate: N/A; AssetIdentifier: N/A; WarrantyStartDate: N/A; TagNumber: N/A; BarCode: N/A; CodePerformance: N/A; Features: N/A; Grade: N/A; SustainabilityPerformance: N/A; Size: 0; HasProtectiveEarth: TRUE; Constituents: N/A; PowerFactor: 0; ModelReference: N/A; NominalFrequencyRange: 0; NumberOfPoles: 0; NominalLength: 0; AccessibilityPerformance: N/A; RatedCurrent: 0; Material: N/A; AssetAccountingType: FIXED; WarrantyDurationLabor: N/A; WarrantyGuarantorLabor: N/A; ReplacementCost: N/A; WarrantyDurationParts: N/A; ExpectedLife: N/A; Shape: N/A; IP_Code: 0; ConductorFunction: L1; NominalHeight: 0; ModelLabel: N/A; WarrantyDescription: N/A; ProductionYear: N/A; RatedVoltage: 0; WarrantyGuarantorParts: N/A; NominalWidth: 0
Mechanical - System Classification: Power,Hydronic Return,Hydronic Supply,Return Air,Supply Air; External Static Pressure: 37.7952; System Name: Hydronic Return 1,Hydronic Supply 1
Constraints - Offset: 0 m; Level: Level: Level 2; Host: Level : Level 2
Energy Analysis - Heating Capacity: 653000279; Cooling Capacity: 607574176
Identity Data - Manufacturer: N/A; OmniClass Title: Modular Indoor Air Handling Units; Type Mark: 1; OmniClass Number: 23.75.35.14.17
Electrical - Voltage: 2238.89; Poles: 3; Load Classification: Cooling
Dimensions - Dimension F: 2.9 m; Dimension A: 9.51444; Length: 6.846 m; Dimension G: 0.695 m; Dimension H: 6.151 m; Dimension E: 1.5 m; Condensate Diameter: 0.328084; Width: 3.175 m; Dimension D: 1.5 m; Condensate Radius: 0.164042; Height: 1.8 m
Name (M_Air Handling Unit - Split System - Horizontal:63300000 J:63300000 J:...) | Panel | Mark
570439 | 1MEC | AHU-1
570459 | 2MEC | AHU-2

# IfcFlowMovingDevice: 991-1905 LPS, M_Centrifugal Fan - Rooftop - Upblast:991-1905 LPS:991-1905 LPS:1062388
In: 3R01
Type - ElementType: 991-1905 LPS; PredefinedType: CENTRIFUGALAIRFOIL; Classification:  (UniFormat)
Constraints - Default Elevation: 1.2 m; Elevation: 0 m; Host: Level : Roof - Main
Electrical - Number of Poles: 3; Voltage: 4951.4; Load Classification: Cooling
Mechanical - RPM: 1564; System Classification: Exhaust Air,Power; System Name: Mechanical Exhaust Air 1; External Static Presure: 37.7952
Electrical - Loads - Apparent Load: 10118.1; Circuit Number: 1; Panel: MS1
Identity Data - OmniClass Title: Centrifugal Fans; Manufacturer: N/A; OmniClass Number: 23.75.35.17.27; Mark: RAF-1
Dimensions - Cap Diameter: 0.5222 m; Outlet Width: 1.47638; Base Width: 0.746 m; Fan Radius: 0.373 m; Cap Radius: 0.2611 m; Fan Diameter: 0.746 m; Overall Height: 0.635 m; Fan Height: 0.489 m; Outlet Height: 1.47638
Other - WarrantyDurationParts: N/A; HasProtectiveEarth: TRUE; Radius 1: 0.3302 m; Diameter 2: 0.5968 m; WarrantyGuarantorLabor: N/A; RatedCurrent: 0; Radius 2: 0.2984 m; ExpectedLife: N/A; NominalFrequencyRange: 0; WarrantyDurationLabor: N/A; Half Outlet Radius: 0.225 m; Half Exhaust Inlet Height: 0.225 m; Diameter 1: 0.6604 m; PowerFactor: 0; NominalLength: 0; Material: N/A; WarrantyGuarantorParts: N/A; Shape: N/A; Size: 0; ConductorFunction: L1; CodePerformance: N/A; AccessibilityPerformance: N/A; AssetAccountingType: FIXED; ReplacementCost: N/A; SustainabilityPerformance: N/A; RatedVoltage: 0; Features: N/A; WarrantyDescription: N/A; ProductionYear: N/A; NumberOfPoles: 0; NominalWidth: 0; ModelReference: N/A; IP_Code: 0; Constituents: N/A; ModelLabel: N/A; NominalHeight: 0; Grade: N/A; WarrantyStartDate: N/A; TagNumber: N/A; Schedule Level: Level: Roof - Main; SerialNumber: N/A; AssetIdentifier: N/A; BarCode: N/A; InstallationDate: N/A
Phasing - Phase Created: New Construction
Mechanical - Flow - Air Flow: 67.2744

# IfcFlowStorageDevice: 380 L, M_Water Heater:380 L:380 L:1061086
In: 2D05
Type - ElementType: 380 L; PredefinedType: PREFORMED; Classification:  (UniFormat)
Electrical - Voltage: 2238.89; Number of Poles: 2; Load Classification: Appliance - Dwelling Unit
Electrical - Loads - Apparent Load: 48437.6; Circuit Number: 6; Panel: MS2
Identity Data - OmniClass Number: 23.65.35.11.11; Manufacturer: N/A; OmniClass Title: Storage Water Heaters; Mark: W.H.
Dimensions - Cold Water Diameter: 0.104987; Vent Diameter: 0.328084; Hot Water Radius: 0.0524934; Vent Radius: 0.164042; Water Heater Height: 1.696 m; Water Heater Radius: 0.337 m; Sanitary Diameter: 0.0492126; Hot Water Diameter: 0.104987; Cold Water Radius: 0.0524934; Sanitary Radius: 0.0246063
Other - ModelReference: N/A; NominalHeight: 0; RatedCurrent: 0; Grade: N/A; Features: N/A; NominalWidth: 0; NominalFrequencyRange: 0; ExpectedLife: N/A; IP_Code: 0; Constituents: N/A; NominalLength: 0; AccessibilityPerformance: N/A; WarrantyDurationParts: N/A; CodePerformance: N/A; Material: N/A; WarrantyGuarantorLabor: N/A; SustainabilityPerformance: N/A; ProductionYear: N/A; Shape: N/A; AssetAccountingType: FIXED; ModelLabel: N/A; WarrantyGuarantorParts: N/A; ConductorFunction: L1; RatedVoltage: 0; Size: 0; ReplacementCost: N/A; HasProtectiveEarth: TRUE; WarrantyDurationLabor: N/A; NumberOfPoles: 0; WarrantyDescription: N/A; PowerFactor: 0; InstallationDate: N/A; TagNumber: N/A; WarrantyStartDate: N/A; BarCode: N/A; AssetIdentifier: N/A; SerialNumber: N/A
Constraints - Offset: 0 m; Host: Level : Level 2; Level: Level: Level 2
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water,Sanitary,Exhaust Air,Power; System Name: Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1,Mechanical Exhaust Air 1
Phasing - Phase Created: New Construction

# IfcFlowTerminal: A2 - 0610x1219mm (26)
Type - ElementType: A2 - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Other - WarrantyStartDate: N/A; Reference: REF TYPE MARK; InstallationDate: N/A; SerialNumber: N/A; BackupSupplySystem: NO; AssetIdentifier: N/A; BarCode: N/A; FixtureHeight: 0; TagNumber: N/A; AssetAccountingType: FIXED; MaintenanceFactor: 0; Features: N/A; PowerFactor: 0; ExpectedLife: N/A; SustainabilityPerformance: N/A; SensibleLoadToRadiant: 0; Material: N/A; Shape: N/A; NominalHeight: 0; ReplacementCost: N/A; AccessibilityPerformance: N/A; HasProtectiveEarth: TRUE; Constituents: N/A; CodePerformance: N/A; RatedCurrent: 0; RatedVoltage: 0; MaximumSpaceSensibleLoad: 0; TotalWattage: 0; MaximumPlenumSensibleLoad: 0; ModelReference: N/A; ModelLabel: N/A; NumberOfSources: 0; WarrantyDescription: N/A; WarrantyDurationLabor: N/A; Size: 0; IP_Code: 0; WarrantyGuarantorLabor: N/A; Grade: N/A; ProductionYear: N/A; NominalFrequencyRange: 0; WarrantyDurationParts: N/A; NominalWidth: 0; NominalLength: 0; NumberOfPoles: 0; WarrantyGuarantorParts: N/A; ConductorFunction: L1
Constraints - Elevation: 2.68 m; Default Elevation: 1.2 m
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Electrical - Loads - Apparent Load: 861.113
Dimensions - Light Source Symbol Size: 0.05 m
Identity Data - OmniClass Title: Downlights; Assembly Code: D5020210; Assembly Description: Lighting - Fluorescent; Description: 610mm X 1219MM (NOMIMAL) RECESSED TROFFER. A-12 PRISMATIC LENS, BAKED WHITE ENAMEL FINISH.; OmniClass Number: 23.80.70.11.14.11; Manufacturer: N/A; Type Mark: A2
Electrical - Ballast Voltage: 1291.67; Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Lamp: T8, 1219mm, RAPID START, CRI=75; Wattage Comments: 32
Photometrics - Color Filter: 16777215; Lumens: 2900; Initial Intensity: 0; Light Loss Factor: 0; Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Dimming Lamp Color Temperature Shift: 0
Materials and Finishes - Light Box Material: Metal - Chrome; Grid Material: Metal - Paint Finish - Dark Gray, Matte; Diffuser Material: Glass - White, High Luminance
Name (M_Troffer Light - Parabolic Rectangular:A2 - 0610x1219mm:A2 - 0610x1219mm:...) | In | Schedule Level | Host | Panel | Circuit Number
739735 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
739751 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
739769 | 1AC4 | Level: Level 1 | <not associated> | N21C1 | 24
739777 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
739783 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
739791 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
739797 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
739813 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
739823 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
739831 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
739841 | 1A14 | Level: Level 1 | <not associated> | N21C1 | 24
740062 | 1A16 | Level: Level 1 | <not associated> | N21C1 | 24
740572 | 1A02 | Level: Level 1 | <not associated> | L41C | 1
740696 | 1AC5 | Level: Level 1 | <not associated> | L41C | 1
740706 | 1A02 | Level: Level 1 | <not associated> | L41C | 1
740714 | 1AC5 | Level: Level 1 | <not associated> | L41C | 1
740724 | 1A02 | Level: Level 1 | <not associated> | L41C | 1
740742 | 1A01 | Level: Level 1 | <not associated> | L41C | 1
740750 | 1A01 | Level: Level 1 | <not associated> | L41C | 1
760938 | 2A12 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 7
761127 | 2A12 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 7
763429 | 2C10 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 1
763552 | 2C10 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 1
764970 | 2C12 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 1
765029 | 2C12 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 1
765075 | 2C12 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 1

# IfcFlowTerminal: A28 - 0610x1219mm (40)
Type - ElementType: A28 - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Constraints - Default Elevation: 1.2 m; Elevation: 2.68 m
Dimensions - Light Source Symbol Size: 0.05 m
Electrical - Loads - Apparent Load: 861.113; Panel: L42C
Electrical - Load Classification: Lighting - Dwelling Unit; Wattage Comments: 32 or 30; Lamp: T8 or TH10, 1219mm, RAPID START, CRI=90; Ballast Number of Poles: 1; Ballast Voltage: 1291.67
Materials and Finishes - Diffuser Material: Glass - White, High Luminance; Grid Material: Metal - Paint Finish - Dark Gray, Matte; Light Box Material: Metal - Chrome
Photometrics - Dimming Lamp Color Temperature Shift: 0; Light Loss Factor: 0; Initial Intensity: 0; Initial Color: 0; Color Filter: 16777215; Lumens: 1800; Light Source Definition (family): Point+HemiSpherical
Identity Data - Assembly Code: D5020210; Description: 610mm X 1219MM (NOMIMAL) RECESSED TROFFER. A-12 PRISMATIC LENS, BAKED WHITE ENAMEL FINISH.; OmniClass Number: 23.80.70.11.14.11; Assembly Description: Lighting - Fluorescent; Manufacturer: N/A; Type Mark: A28; OmniClass Title: Downlights
Other - WarrantyDescription: N/A; ProductionYear: N/A; ModelLabel: N/A; SensibleLoadToRadiant: 0; ModelReference: N/A; WarrantyDurationLabor: N/A; MaintenanceFactor: 0; RatedCurrent: 0; Shape: N/A; NumberOfSources: 0; Material: N/A; TotalWattage: 0; CodePerformance: N/A; ExpectedLife: N/A; MaximumSpaceSensibleLoad: 0; PowerFactor: 0; WarrantyGuarantorParts: N/A; RatedVoltage: 0; IP_Code: 0; ReplacementCost: N/A; Size: 0; NominalWidth: 0; HasProtectiveEarth: TRUE; Grade: N/A; Features: N/A; NumberOfPoles: 0; NominalLength: 0; AssetAccountingType: FIXED; MaximumPlenumSensibleLoad: 0; NominalFrequencyRange: 0; Constituents: N/A; ConductorFunction: L1; SustainabilityPerformance: N/A; AccessibilityPerformance: N/A; WarrantyGuarantorLabor: N/A; NominalHeight: 0; WarrantyDurationParts: N/A; FixtureHeight: 0; SerialNumber: N/A; TagNumber: N/A; AssetIdentifier: N/A; BackupSupplySystem: NO; WarrantyStartDate: N/A; Reference: REF TYPE MARK; InstallationDate: N/A; Schedule Level: Level: Level 2; BarCode: N/A
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Name (M_Troffer Light - Parabolic Rectangular:A28 - 0610x1219mm:A28 - 0610x1219mm:...) | In | Circuit Number | Host
757047 | 2C14 | 1 | Linked Revit Model : Clinic_A.rvt
757176 | 2C14 | 1 | Linked Revit Model : Clinic_A.rvt
757212 | 2C14 | 1 | Linked Revit Model : Clinic_A.rvt
757290 | 2C14 | 1 | Linked Revit Model : Clinic_A.rvt
757939 | 2C09 | 5 | Linked Revit Model : Clinic_A.rvt
758020 | 2C09 | 5 | Linked Revit Model : Clinic_A.rvt
758065 | 2C09 | 5 | <not associated>
758137 | 2C09 | 5 | Linked Revit Model : Clinic_A.rvt
758214 | 2C06 | 5 | <not associated>
758349 | 2C06 | 5 | Linked Revit Model : Clinic_A.rvt
758406 | 2C06 | 5 | Linked Revit Model : Clinic_A.rvt
758485 | 2C06 | 5 | Linked Revit Model : Clinic_A.rvt
758524 | 2C04 | 4 | Linked Revit Model : Clinic_A.rvt
758566 | 2C04 | 4 | Linked Revit Model : Clinic_A.rvt
758595 | 2C04 | 4 | Linked Revit Model : Clinic_A.rvt
758632 | 2C04 | 4 | Linked Revit Model : Clinic_A.rvt
758668 | 2C02 | 4 | <not associated>
758695 | 2C02 | 4 | Linked Revit Model : Clinic_A.rvt
758706 | 2C02 | 4 | Linked Revit Model : Clinic_A.rvt
758716 | 2C02 | 4 | Linked Revit Model : Clinic_A.rvt
758733 | 2A09 | 4 | Linked Revit Model : Clinic_A.rvt
758776 | 2A09 | 4 | Linked Revit Model : Clinic_A.rvt
758823 | 2A09 | 4 | Linked Revit Model : Clinic_A.rvt
758854 | 2A09 | 4 | Linked Revit Model : Clinic_A.rvt
758896 | 2A08 | 4 | Linked Revit Model : Clinic_A.rvt
758959 | 2A08 | 4 | Linked Revit Model : Clinic_A.rvt
759007 | 2A08 | 4 | Linked Revit Model : Clinic_A.rvt
759055 | 2A08 | 4 | Linked Revit Model : Clinic_A.rvt
759156 | 2A07 | 8 | Linked Revit Model : Clinic_A.rvt
759199 | 2A07 | 8 | Linked Revit Model : Clinic_A.rvt
759249 | 2A07 | 8 | Linked Revit Model : Clinic_A.rvt
759301 | 2A07 | 8 | Linked Revit Model : Clinic_A.rvt
759356 | 2A06 | 8 | Linked Revit Model : Clinic_A.rvt
759447 | 2A06 | 8 | Linked Revit Model : Clinic_A.rvt
759535 | 2A06 | 8 | Linked Revit Model : Clinic_A.rvt
759607 | 2A06 | 8 | Linked Revit Model : Clinic_A.rvt
759666 | 2A05 | 8 | Linked Revit Model : Clinic_A.rvt
759747 | 2A05 | 8 | Linked Revit Model : Clinic_A.rvt
759797 | 2A05 | 8 | Linked Revit Model : Clinic_A.rvt
759855 | 2A05 | 8 | Linked Revit Model : Clinic_A.rvt

# IfcFlowTerminal: A2B - 0610x1219mm (10)
Type - ElementType: A2B - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Other - Reference: REF TYPE MARK; FixtureHeight: 0; WarrantyStartDate: N/A; BarCode: N/A; InstallationDate: N/A; BackupSupplySystem: YES; SerialNumber: N/A; TagNumber: N/A; AssetIdentifier: N/A; ProductionYear: N/A; Size: 0; MaximumPlenumSensibleLoad: 0; WarrantyDurationParts: N/A; Grade: N/A; NominalWidth: 0; NumberOfPoles: 0; IP_Code: 0; SensibleLoadToRadiant: 0; Shape: N/A; TotalWattage: 0; SustainabilityPerformance: N/A; WarrantyGuarantorParts: N/A; ReplacementCost: N/A; MaximumSpaceSensibleLoad: 0; PowerFactor: 0; CodePerformance: N/A; NominalFrequencyRange: 0; Features: N/A; RatedCurrent: 0; NominalLength: 0; RatedVoltage: 0; WarrantyGuarantorLabor: N/A; Constituents: N/A; MaintenanceFactor: 0; WarrantyDescription: N/A; ModelLabel: N/A; Material: N/A; NumberOfSources: 0; ConductorFunction: L1; HasProtectiveEarth: TRUE; NominalHeight: 0; AssetAccountingType: FIXED; WarrantyDurationLabor: N/A; ExpectedLife: N/A; AccessibilityPerformance: N/A; ModelReference: N/A
Constraints - Elevation: 2.68 m; Default Elevation: 1.2 m
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Electrical - Loads - Apparent Load: 861.113
Materials and Finishes - Grid Material: Metal - Paint Finish - Dark Gray, Matte; Diffuser Material: Glass - White, High Luminance; Light Box Material: Metal - Chrome
Dimensions - Light Source Symbol Size: 0.05 m
Identity Data - Assembly Code: D5020210; Manufacturer: N/A; Description: SAME AS A2 EXCEPT WITH EMERGENCY BATTERY PACK; Assembly Description: Lighting - Fluorescent; Type Mark: A2B; OmniClass Title: Downlights; OmniClass Number: 23.80.70.11.14.11
Photometrics - Light Source Definition (family): Point+HemiSpherical; Color Filter: 16777215; Dimming Lamp Color Temperature Shift: 0; Initial Intensity: 0; Initial Color: 0; Lumens: 2900; Light Loss Factor: 0
Electrical - Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Ballast Voltage: 1291.67; Wattage Comments: 32; Lamp: T8, 1219mm, RAPID START, CRI=75
Name (M_Troffer Light - Parabolic Rectangular:A2B - 0610x1219mm:A2B - 0610x1219mm:...) | In | Schedule Level | Host | Circuit Number | Panel
739743 | 1A16 | Level: Level 1 | <not associated> | 24 | N21C1
739761 | 1A16 | Level: Level 1 | <not associated> | 24 | N21C1
739805 | 1A16 | Level: Level 1 | <not associated> | 24 | N21C1
740732 | 1AC5 | Level: Level 1 | <not associated> | 1 | L41C
740844 | 1D40 | Level: Level 1 | <not associated> | 4 | L41B
740852 | 1D40 | Level: Level 1 | <not associated> | 4 | L41B
740860 | 1D40 | Level: Level 1 | <not associated> | 4 | L41B
756865 | 2C16 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | 1 | L42C
756954 | 2C16 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | 1 | L42C
761042 | 2A12 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | 7 | L42C

# IfcFlowTerminal: B1 - 0610x1219mm (252)
Type - ElementType: B1 - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Other - BackupSupplySystem: NO; WarrantyStartDate: N/A; BarCode: N/A; TagNumber: N/A; SerialNumber: N/A; AssetIdentifier: N/A; InstallationDate: N/A; Reference: REF TYPE MARK; FixtureHeight: 0; ModelLabel: N/A; ExpectedLife: N/A; IP_Code: 0; NumberOfSources: 0; SensibleLoadToRadiant: 0; RatedVoltage: 0; Shape: N/A; AssetAccountingType: FIXED; NominalLength: 0; SustainabilityPerformance: N/A; WarrantyDurationParts: N/A; MaximumSpaceSensibleLoad: 0; Size: 0; RatedCurrent: 0; WarrantyDescription: N/A; WarrantyGuarantorLabor: N/A; MaintenanceFactor: 0; NumberOfPoles: 0; WarrantyDurationLabor: N/A; PowerFactor: 0; Features: N/A; AccessibilityPerformance: N/A; ModelReference: N/A; NominalWidth: 0; CodePerformance: N/A; NominalFrequencyRange: 0; ReplacementCost: N/A; NominalHeight: 0; Material: N/A; Grade: N/A; WarrantyGuarantorParts: N/A; ProductionYear: N/A; HasProtectiveEarth: TRUE; Constituents: N/A; ConductorFunction: L1; TotalWattage: 0; MaximumPlenumSensibleLoad: 0
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Constraints - Elevation: 2.68 m; Default Elevation: 1.2 m
Electrical - Loads - Apparent Load: 861.113
Dimensions - Light Source Symbol Size: 0.05 m
Materials and Finishes - Grid Material: Metal - Paint Finish - Dark Gray, Matte; Light Box Material: Metal - Chrome; Diffuser Material: Glass - White, High Luminance
Electrical - Lamp: T8, 1219mm, RAPID START, CRI=75; Ballast Voltage: 1291.67; Wattage Comments: 32; Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit
Photometrics - Light Source Definition (family): Point+HemiSpherical; Lumens: 2900; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215; Initial Intensity: 0; Initial Color: 0; Light Loss Factor: 0
Identity Data - Assembly Code: D5020210; Assembly Description: Lighting - Fluorescent; OmniClass Title: Downlights; Description: 610mm X 1219MM (NOMIMAL) RECESSED TROFFER. A-12 PRISMATIC LENS, BAKED WHITE ENAMEL FINISH.; Type Mark: B1; Manufacturer: N/A; OmniClass Number: 23.80.70.11.14.11
Name (M_Troffer Light - Parabolic Rectangular:B1 - 0610x1219mm:B1 - 0610x1219mm:...) | In | Schedule Level | Circuit Number | Panel | Host
737660 | 1B06 | Level: Level 1 | 1 | L41B | Linked Revit Model : Clinic_A.rvt
737678 | 1B06 | Level: Level 1 | 1 | L41B | <not associated>
738197 | 1B08 | Level: Level 1 | 1 | L41B | Linked Revit Model : Clinic_A.rvt
738199 | 1B08 | Level: Level 1 | 1 | L41B | <not associated>
738238 | 1B10 | Level: Level 1 | 1 | L41B | Linked Revit Model : Clinic_A.rvt
738239 | 1B10 | Level: Level 1 | 1 | L41B | <not associated>
738254 | 1B04 | Level: Level 1 | 1 | L41B | Linked Revit Model : Clinic_A.rvt
738255 | 1B04 | Level: Level 1 | 1 | L41B | <not associated>
738265 | 1B04 | Level: Level 1 | 1 | L41B | <not associated>
738276 | 1B04 | Level: Level 1 | 1 | L41B | Linked Revit Model : Clinic_A.rvt
738277 | 1B04 | Level: Level 1 | 1 | L41B | <not associated>
738286 | 1B04 | Level: Level 1 | 1 | L41B | Linked Revit Model : Clinic_A.rvt
738383 | 1B04 | Level: Level 1 | 1 | L41B | <not associated>
738419 | 1E05 | Level: Level 1 | 3 | L41B | <not associated>
738483 | 1E05 | Level: Level 1 | 3 | L41B | <not associated>
738491 | 1E06 | Level: Level 1 | 3 | L41B | <not associated>
738499 | 1E06 | Level: Level 1 | 3 | L41B | <not associated>
738507 | 1E06 | Level: Level 1 | 3 | L41B | <not associated>
738515 | 1E06 | Level: Level 1 | 3 | L41B | <not associated>
738523 | 1E06 | Level: Level 1 | 3 | L41B | <not associated>
738547 | 1E08 | Level: Level 1 | 3 | L41B | <not associated>
738653 | 1E11 | Level: Level 1 | 3 | L41B | <not associated>
738661 | 1E11 | Level: Level 1 | 3 | L41B | <not associated>
738675 | 1E33 | Level: Level 1 | 3 | L41B | <not associated>
738685 | 1E33 | Level: Level 1 | 3 | L41B | <not associated>
738695 | 1E14 | Level: Level 1 | 5 | L41B | <not associated>
738703 | 1E14 | Level: Level 1 | 5 | L41B | <not associated>
738713 | 1E14 | Level: Level 1 | 5 | L41B | <not associated>
738729 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
738776 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
738788 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
738800 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
738810 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
738820 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
738828 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
738877 | 1D35 | Level: Level 1 | 4 | L41B | <not associated>
738885 | 1D35 | Level: Level 1 | 4 | L41B | <not associated>
738895 | 1D33 | Level: Level 1 | 4 | L41B | <not associated>
738903 | 1D33 | Level: Level 1 | 4 | L41B | <not associated>
738913 | 1D31 | Level: Level 1 | 4 | L41B | <not associated>
738921 | 1D31 | Level: Level 1 | 4 | L41B | <not associated>
738931 | 1D30 | Level: Level 1 | 4 | L41B | <not associated>
738939 | 1D30 | Level: Level 1 | 4 | L41B | <not associated>
738965 | 1D27 | Level: Level 1 | 5 | L41B | <not associated>
738973 | 1D27 | Level: Level 1 | 5 | L41B | <not associated>
738981 | 1D24 | Level: Level 1 | 5 | L41B | <not associated>
738991 | 1D24 | Level: Level 1 | 5 | L41B | <not associated>
738999 | 1D23 | Level: Level 1 | 5 | L41B | <not associated>
739007 | 1D23 | Level: Level 1 | 5 | L41B | <not associated>
739015 | 1D23 | Level: Level 1 | 5 | L41B | <not associated>
739023 | 1D23 | Level: Level 1 | 5 | L41B | <not associated>
739033 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
739041 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
739076 | 1D25 | Level: Level 1 | 5 | L41B | <not associated>
739090 | 1D22 | Level: Level 1 | 5 | L41C | <not associated>
739108 | 1D22 | Level: Level 1 | 5 | L41C | <not associated>
739116 | 1D21 | Level: Level 1 | 5 | L41C | <not associated>
739124 | 1D21 | Level: Level 1 | 5 | L41C | <not associated>
739132 | 1D21 | Level: Level 1 | 5 | L41C | <not associated>
739140 | 1D21 | Level: Level 1 | 5 | L41C | <not associated>
739150 | 1D20 | Level: Level 1 | 5 | L41C | <not associated>
739158 | 1D20 | Level: Level 1 | 5 | L41C | <not associated>
739174 | 1D19 | Level: Level 1 | 5 | L41C | <not associated>
739182 | 1D18 | Level: Level 1 | 5 | L41C | <not associated>
739192 | 1D15 | Level: Level 1 | 3 | L41C | <not associated>
739372 | 1D16 | Level: Level 1 | 5 | L41C | <not associated>
739380 | 1D16 | Level: Level 1 | 5 | L41C | <not associated>
739400 | 1D16 | Level: Level 1 | 5 | L41C | <not associated>
739408 | 1D16 | Level: Level 1 | 5 | L41C | <not associated>
739428 | 1D16 | Level: Level 1 | 5 | L41C | <not associated>
739434 | 1D16 | Level: Level 1 | 5 | L41C | <not associated>
739442 | 1D16 | Level: Level 1 | 5 | L41C | <not associated>
739460 | 1D16 | Level: Level 1 | 5 | L41C | <not associated>
739468 | 1D16 | Level: Level 1 | 5 | L41C | <not associated>
739639 | 1C14 | Level: Level 1 | 4 | L41C | <not associated>
739647 | 1C14 | Level: Level 1 | 4 | L41C | <not associated>
739691 | 1C06 | Level: Level 1 | 9 | L41C | <not associated>
739715 | 1A10 | Level: Level 1 | 23 | N21C1 | <not associated>
739725 | 1A10 | Level: Level 1 | 23 | N21C1 | <not associated>
739849 | 1A15 | Level: Level 1 | 24 | N21C1 | <not associated>
739861 | 1A15 | Level: Level 1 | 24 | N21C1 | <not associated>
739871 | 1A03 | Level: Level 1 | 1 | L41C | <not associated>
739879 | 1A03 | Level: Level 1 | 1 | L41C | <not associated>
739891 | 1A05 | Level: Level 1 | 1 | L41C | <not associated>
739901 | 1A05 | Level: Level 1 | 1 | L41C | <not associated>
739911 | 1A04 | Level: Level 1 | 1 | L41C | <not associated>
739919 | 1A04 | Level: Level 1 | 1 | L41C | <not associated>
740028 | 1A06 | Level: Level 1 | 1 | L41C | <not associated>
740036 | 1A06 | Level: Level 1 | 1 | L41C | <not associated>
740044 | 1A07 | Level: Level 1 | 1 | L41C | <not associated>
740052 | 1A07 | Level: Level 1 | 1 | L41C | <not associated>
740074 | 1E16 | Level: Level 1 | 6 | L41B | <not associated>
740090 | 1E16 | Level: Level 1 | 6 | L41B | <not associated>
740102 | 1E16 | Level: Level 1 | 6 | L41B | <not associated>
740112 | 1E16 | Level: Level 1 | 6 | L41B | <not associated>
740120 | 1E16 | Level: Level 1 | 6 | L41B | <not associated>
740128 | 1E16 | Level: Level 1 | 6 | L41B | <not associated>
740142 | 1E16 | Level: Level 1 | 6 | L41B | <not associated>
740152 | 1E16 | Level: Level 1 | 6 | L41B | <not associated>
740164 | 1E18 | Level: Level 1 | 6 | L41B | <not associated>
740172 | 1E18 | Level: Level 1 | 6 | L41B | <not associated>
740180 | 1E18 | Level: Level 1 | 6 | L41B | <not associated>
740188 | 1E30 | Level: Level 1 | 6 | L41B | <not associated>
740198 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740206 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740222 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740236 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740244 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740252 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740264 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740274 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740282 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740292 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740300 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740310 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740318 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740326 | 1E24 | Level: Level 1 | 7 | L41B | <not associated>
740439 | 1E29 | Level: Level 1 | 7 | L41B | <not associated>
740440 | 1E29 | Level: Level 1 | 7 | L41B | <not associated>
740475 | 1E26 | Level: Level 1 | 7 | L41B | <not associated>
740485 | 1E26 | Level: Level 1 | 7 | L41B | <not associated>
740497 | 1E26 | Level: Level 1 | 7 | L41B | <not associated>
740505 | 1E27 | Level: Level 1 | 7 | L41B | <not associated>
740515 | 1E28 | Level: Level 1 | 7 | L41B | <not associated>
740523 | 1E28 | Level: Level 1 | 7 | L41B | <not associated>
740762 | 1A08 | Level: Level 1 | 23 | N21C1 | <not associated>
740770 | 1A08 | Level: Level 1 | 23 | N21C1 | <not associated>
740780 | 1A09 | Level: Level 1 | 23 | N21C1 | <not associated>
740788 | 1A12 | Level: Level 1 | 23 | N21C1 | <not associated>
740834 | 1C02 | Level: Level 1 | 22 | N21C1 | <not associated>
740882 | 1E01 | Level: Level 1 | 3 | L41B | <not associated>
740922 | 1E04 | Level: Level 1 | 3 | L41B | <not associated>
740932 | 1E22 | Level: Level 1 | 6 | L41B | <not associated>
740944 | 1E23 | Level: Level 1 | 6 | L41B | <not associated>
740952 | 1E23 | Level: Level 1 | 6 | L41B | <not associated>
740966 | 1B17 | Level: Level 1 | 1 | L41B | <not associated>
740982 | 1B17 | Level: Level 1 | 1 | L41B | <not associated>
740992 | 1B13 | Level: Level 1 | 1 | L41B | <not associated>
741000 | 1B13 | Level: Level 1 | 1 | L41B | <not associated>
741008 | 1B13 | Level: Level 1 | 1 | L41B | <not associated>
741014 | 1B13 | Level: Level 1 | 1 | L41B | <not associated>
741034 | 1B13 | Level: Level 1 | 1 | L41B | <not associated>
741068 | 1B01 | Level: Level 1 | 1 | L41B | <not associated>
741074 | 1B01 | Level: Level 1 | 1 | L41B | <not associated>
743971 | 1C17 | Level: Level 1 | 4 | L41C | <not associated>
744063 | 1C17 | Level: Level 1 | 4 | L41C | <not associated>
744088 | 1C18 | Level: Level 1 | 4 | L41C | <not associated>
757334 | 2C13 | Level: Level 2 | 1 | L42C | Linked Revit Model : Clinic_A.rvt
759928 | 2A04 | Level: Level 2 | 6 | L42C | Linked Revit Model : Clinic_A.rvt
760014 | 2A04 | Level: Level 2 | 6 | L42C | Linked Revit Model : Clinic_A.rvt
760132 | 2A03 | Level: Level 2 | 6 | L42C | Linked Revit Model : Clinic_A.rvt
760217 | 2A03 | Level: Level 2 | 6 | L42C | Linked Revit Model : Clinic_A.rvt
760486 | 2A02 | Level: Level 2 | 6 | L42C | Linked Revit Model : Clinic_A.rvt
760579 | 2A02 | Level: Level 2 | 6 | L42C | Linked Revit Model : Clinic_A.rvt
760806 | 2A13 | Level: Level 2 | 7 | L42C | Linked Revit Model : Clinic_A.rvt
761518 | 2A11 | Level: Level 2 | 7 | L42C | <not associated>
761620 | 2A11 | Level: Level 2 | 7 | L42C | <not associated>
761838 | 2A11 | Level: Level 2 | 7 | L42C | Linked Revit Model : Clinic_A.rvt
761900 | 2A14 | Level: Level 2 | 7 | L42C | Linked Revit Model : Clinic_A.rvt
762032 | 2A14 | Level: Level 2 | 7 | L42C | Linked Revit Model : Clinic_A.rvt
762088 | 2A14 | Level: Level 2 | 7 | L42C | Linked Revit Model : Clinic_A.rvt
762164 | 2A14 | Level: Level 2 | 7 | L42C | Linked Revit Model : Clinic_A.rvt
762237 | 2A14 | Level: Level 2 | 7 | L42C | <not associated>
763756 | 2C08 | Level: Level 2 | 2 | L42C | Linked Revit Model : Clinic_A.rvt
763883 | 2C07 | Level: Level 2 | 2 | L42C | <not associated>
763991 | 2C07 | Level: Level 2 | 2 | L42C | Linked Revit Model : Clinic_A.rvt
765207 | 2C19 | Level: Level 2 | 2 | L42C | Linked Revit Model : Clinic_A.rvt
765269 | 2C19 | Level: Level 2 | 2 | L42C | Linked Revit Model : Clinic_A.rvt
765313 | 2C19 | Level: Level 2 | 2 | L42C | Linked Revit Model : Clinic_A.rvt
765468 | 2C08 | Level: Level 2 | 2 | L42C | Linked Revit Model : Clinic_A.rvt
766021 | 2C22 | Level: Level 2 | 2 | L42C | Linked Revit Model : Clinic_A.rvt
766086 | 2C22 | Level: Level 2 | 2 | L42C | Linked Revit Model : Clinic_A.rvt
766284 | 2B3 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
766379 | 2B3 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
766443 | 2B3 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
766551 | 2B3 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
766791 | 2B7 | Level: Level 2 | 1 | L42B | <not associated>
766836 | 2B7 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
766933 | 2B9 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
767010 | 2B9 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
767247 | 2D03 | Level: Level 2 | 2 | L42B | <not associated>
767338 | 2D03 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
767412 | 2D04 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
767463 | 2D04 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
767675 | 2D01 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
767811 | 2D02 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
767896 | 2D04-A | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
767959 | 2D04-A | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
767999 | 2D04-A | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
768080 | 2D04-A | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
768139 | 2D04-A | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
768213 | 2D04-A | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
768435 | 2D09 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
768528 | 2D09 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
768636 | 2D08 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
768769 | 2D08 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
768866 | 2D07 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
768973 | 2D07 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
769040 | 2D06 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
769117 | 2D06 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
769515 | 2D11 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
769575 | 2D11 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
769664 | 2D16 | Level: Level 2 | 6 | L42B | <not associated>
769730 | 2D16 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
770065 | 2D14 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
770158 | 2D14 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
770241 | 2D15 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
770319 | 2D15 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
770454 | 2D17 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
770488 | 2D17 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
770554 | 2D19 | Level: Level 2 | 6 | L42B | <not associated>
770646 | 2D19 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt
770733 | 2D20 | Level: Level 2 | 7 | L42B | Linked Revit Model : Clinic_A.rvt
770803 | 2D20 | Level: Level 2 | 7 | L42B | Linked Revit Model : Clinic_A.rvt
770835 | 2D20 | Level: Level 2 | 7 | L42B | Linked Revit Model : Clinic_A.rvt
770871 | 2D20 | Level: Level 2 | 7 | L42B | Linked Revit Model : Clinic_A.rvt
770900 | 2D20 | Level: Level 2 | 7 | L42B | Linked Revit Model : Clinic_A.rvt
770937 | 2D21 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
771103 | 2D21 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
771155 | 2D21 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
771219 | 2D21 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
771279 | 2D21 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
771351 | 2D21 | Level: Level 2 | 2 | L42B | Linked Revit Model : Clinic_A.rvt
771541 | 2B16 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
771644 | 2B16 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
771695 | 2B18 | Level: Level 2 | 1 | L42B | <not associated>
771736 | 2B18 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
771838 | 2B21 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
771897 | 2B21 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
771988 | 2B23 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
772036 | 2B23 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
772088 | 2B24 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
772157 | 2B24 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
772253 | 2B01 | Level: Level 2 | 1 | L42B | <not associated>
772330 | 2B01 | Level: Level 2 | 1 | L42B | Linked Revit Model : Clinic_A.rvt
772499 | 2B25 | Level: Level 2 | 3 | L42B | Linked Revit Model : Clinic_A.rvt
772665 | 2B19 | Level: Level 2 | 3 | L42B | Linked Revit Model : Clinic_A.rvt
772734 | 2B19 | Level: Level 2 | 3 | L42B | Linked Revit Model : Clinic_A.rvt
773095 | 2B14 | Level: Level 2 | 3 | L42B | Linked Revit Model : Clinic_A.rvt
773147 | 2B14 | Level: Level 2 | 3 | L42B | <not associated>
773282 | 2B10 | Level: Level 2 | 3 | L42B | Linked Revit Model : Clinic_A.rvt
773329 | 2B10 | Level: Level 2 | 3 | L42B | Linked Revit Model : Clinic_A.rvt
773377 | 2B10 | Level: Level 2 | 3 | L42B | Linked Revit Model : Clinic_A.rvt
773497 | 2B8 | Level: Level 2 | 3 | L42B | <not associated>
773564 | 2B8 | Level: Level 2 | 3 | L42B | Linked Revit Model : Clinic_A.rvt
773621 | 2B8 | Level: Level 2 | 3 | L42B | Linked Revit Model : Clinic_A.rvt
783980 | 2A10 | Level: Level 2 | 7 | L42C | Linked Revit Model : Clinic_A.rvt
783989 | 2A10 | Level: Level 2 | 7 | L42C | Linked Revit Model : Clinic_A.rvt
826140 | 1E07 | Level: Level 1 | 3 | L41B | <not associated>
826172 | 1E07 | Level: Level 1 | 3 | L41B | <not associated>
826180 | 1E07 | Level: Level 1 | 3 | L41B | <not associated>
826190 | 1E07 | Level: Level 1 | 3 | L41B | <not associated>

# IfcFlowTerminal: B18 - 0610x1219mm (10)
Type - ElementType: B18 - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Other - FixtureHeight: 0; AssetIdentifier: N/A; TagNumber: N/A; InstallationDate: N/A; SerialNumber: N/A; WarrantyStartDate: N/A; Reference: REF TYPE MARK; BarCode: N/A; Schedule Level: Level: Level 1; BackupSupplySystem: NO; CodePerformance: N/A; MaximumPlenumSensibleLoad: 0; MaintenanceFactor: 0; ModelReference: N/A; Size: 0; WarrantyDurationLabor: N/A; Features: N/A; Shape: N/A; WarrantyDescription: N/A; Constituents: N/A; NominalHeight: 0; NominalLength: 0; PowerFactor: 0; SensibleLoadToRadiant: 0; ReplacementCost: N/A; RatedVoltage: 0; Grade: N/A; WarrantyGuarantorParts: N/A; NumberOfSources: 0; NominalFrequencyRange: 0; NominalWidth: 0; NumberOfPoles: 0; AssetAccountingType: FIXED; IP_Code: 0; RatedCurrent: 0; AccessibilityPerformance: N/A; SustainabilityPerformance: N/A; ExpectedLife: N/A; HasProtectiveEarth: TRUE; MaximumSpaceSensibleLoad: 0; Material: N/A; ProductionYear: N/A; WarrantyGuarantorLabor: N/A; ConductorFunction: L1; WarrantyDurationParts: N/A; TotalWattage: 0; ModelLabel: N/A
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Constraints - Elevation: 2.68 m; Host: <not associated>; Default Elevation: 1.2 m
Phasing - Phase Created: New Construction
Materials and Finishes - Diffuser Material: Glass - White, High Luminance; Grid Material: Metal - Paint Finish - Dark Gray, Matte; Light Box Material: Metal - Chrome
Photometrics - Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215; Lumens: 2900; Initial Intensity: 0; Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0
Electrical - Loads - Apparent Load: 861.113
Electrical - Wattage Comments: 32; Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Lamp: T8, 1219mm, RAPID START, CRI=85 MINI; Ballast Voltage: 1291.67
Identity Data - Manufacturer: N/A; Description: SAME AS B1 EXCEPT 85 COLOR RENDERING LAMPS; OmniClass Number: 23.80.70.11.14.11; Assembly Code: D5020210; OmniClass Title: Downlights; Assembly Description: Lighting - Fluorescent; Type Mark: B18
Dimensions - Light Source Symbol Size: 0.05 m
Name (M_Troffer Light - Parabolic Rectangular:B18 - 0610x1219mm:B18 - 0610x1219mm:...) | In | Panel | Circuit Number
739202 | 1D12 | L41C | 3
739210 | 1D12 | L41C | 3
739655 | 1C16 | L41C | 4
739663 | 1C16 | L41C | 4
739671 | 1C19 | L41C | 4
740798 | 1C07 | N21C1 | 22
740806 | 1C07 | N21C1 | 22
740814 | 1C10 | N21C1 | 22
740824 | 1C10 | N21C1 | 22
743160 | 1C19 | L41C | 4

# IfcFlowTerminal: B1B - 0610x1219mm (22)
Type - ElementType: B1B - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Other - BackupSupplySystem: YES; BarCode: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; Reference: REF TYPE MARK; AssetIdentifier: N/A; SerialNumber: N/A; TagNumber: N/A; FixtureHeight: 0; Material: N/A; RatedCurrent: 0; NominalWidth: 0; IP_Code: 0; SensibleLoadToRadiant: 0; Features: N/A; WarrantyGuarantorLabor: N/A; ModelReference: N/A; ReplacementCost: N/A; NumberOfSources: 0; WarrantyDurationLabor: N/A; AssetAccountingType: FIXED; WarrantyGuarantorParts: N/A; PowerFactor: 0; Size: 0; Grade: N/A; RatedVoltage: 0; MaximumPlenumSensibleLoad: 0; NominalHeight: 0; ModelLabel: N/A; CodePerformance: N/A; ExpectedLife: N/A; WarrantyDescription: N/A; ConductorFunction: L1; TotalWattage: 0; NominalFrequencyRange: 0; WarrantyDurationParts: N/A; MaintenanceFactor: 0; Shape: N/A; ProductionYear: N/A; NumberOfPoles: 0; MaximumSpaceSensibleLoad: 0; HasProtectiveEarth: TRUE; NominalLength: 0; Constituents: N/A; AccessibilityPerformance: N/A; SustainabilityPerformance: N/A
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Constraints - Elevation: 2.68 m; Default Elevation: 1.2 m
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Dimensions - Light Source Symbol Size: 0.05 m
Electrical - Lamp: T8, 1219mm, RAPID START, CRI=75; Ballast Voltage: 1291.67; Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Wattage Comments: 32
Materials and Finishes - Diffuser Material: Glass - White, High Luminance; Light Box Material: Metal - Chrome; Grid Material: Metal - Paint Finish - Dark Gray, Matte
Electrical - Loads - Apparent Load: 861.113
Photometrics - Lumens: 2900; Dimming Lamp Color Temperature Shift: 0; Initial Color: 0; Initial Intensity: 0; Color Filter: 16777215; Light Loss Factor: 0; Light Source Definition (family): Point+HemiSpherical
Identity Data - Assembly Code: D5020210; OmniClass Number: 23.80.70.11.14.11; Type Mark: B1B; Assembly Description: Lighting - Fluorescent; Manufacturer: N/A; Description: SAME AS B1 EXCEPT WITH EMERGENCY BATTERY PACK; OmniClass Title: Downlights
Name (M_Troffer Light - Parabolic Rectangular:B1B - 0610x1219mm:B1B - 0610x1219mm:...) | In | Schedule Level | Host | Panel | Circuit Number
738264 | 1B04 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | L41B | 1
738287 | 1B04 | Level: Level 1 | <not associated> | L41B | 1
738531 | 1E06 | Level: Level 1 | <not associated> | L41B | 3
738838 | 1D25 | Level: Level 1 | <not associated> | L41B | 5
739098 | 1D22 | Level: Level 1 | <not associated> | L41C | 5
739388 | 1D16 | Level: Level 1 | <not associated> | L41C | 5
739420 | 1D16 | Level: Level 1 | <not associated> | L41C | 5
740082 | 1E16 | Level: Level 1 | <not associated> | L41B | 6
740134 | 1E16 | Level: Level 1 | <not associated> | L41B | 6
740214 | 1E24 | Level: Level 1 | <not associated> | L41B | 7
740334 | 1E24 | Level: Level 1 | <not associated> | L41B | 7
740467 | 1E26 | Level: Level 1 | <not associated> | L41B | 7
740974 | 1B17 | Level: Level 1 | <not associated> | L41B | 1
761434 | 2A11 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 7
761751 | 2A11 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 7
762334 | 2A14 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 7
763665 | 2C08 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 2
767557 | 2D04 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42B | 2
770782 | 2D20 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42B | 7
773454 | 2B10 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42B | 3
773871 | 2C24 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 2
773998 | 2C23 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | 2

# IfcFlowTerminal: B1D - 0610x1219mm (4)
Type - ElementType: B1D - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Other - FixtureHeight: 0; TagNumber: N/A; InstallationDate: N/A; Schedule Level: Level: Level 1; BackupSupplySystem: NO; BarCode: N/A; SerialNumber: N/A; Reference: REF TYPE MARK; AssetIdentifier: N/A; WarrantyStartDate: N/A; ExpectedLife: N/A; NominalLength: 0; Material: N/A; Features: N/A; MaximumSpaceSensibleLoad: 0; CodePerformance: N/A; NominalHeight: 0; PowerFactor: 0; NumberOfPoles: 0; TotalWattage: 0; NominalFrequencyRange: 0; ReplacementCost: N/A; ConductorFunction: L1; SustainabilityPerformance: N/A; NominalWidth: 0; MaximumPlenumSensibleLoad: 0; RatedVoltage: 0; MaintenanceFactor: 0; WarrantyDurationParts: N/A; IP_Code: 0; AccessibilityPerformance: N/A; ModelReference: N/A; WarrantyDurationLabor: N/A; WarrantyDescription: N/A; ModelLabel: N/A; Constituents: N/A; SensibleLoadToRadiant: 0; NumberOfSources: 0; AssetAccountingType: FIXED; WarrantyGuarantorLabor: N/A; Shape: N/A; RatedCurrent: 0; WarrantyGuarantorParts: N/A; ProductionYear: N/A; HasProtectiveEarth: TRUE; Grade: N/A; Size: 0
Electrical - Loads - Panel: L41C; Circuit Number: 9; Apparent Load: 861.113
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Constraints - Host: <not associated>; Elevation: 2.68 m; Default Elevation: 1.2 m
Materials and Finishes - Diffuser Material: Glass - White, High Luminance; Light Box Material: Metal - Chrome; Grid Material: Metal - Paint Finish - Dark Gray, Matte
Dimensions - Light Source Symbol Size: 0.05 m
Photometrics - Dimming Lamp Color Temperature Shift: 0; Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Color: 0; Lumens: 2900; Color Filter: 16777215; Initial Intensity: 0
Identity Data - Assembly Code: D5020210; OmniClass Number: 23.80.70.11.14.11; Description: SAME AS B1 EXCEPT WITH DIMMING BALLAST; Type Mark: B1D; Assembly Description: Lighting - Fluorescent; OmniClass Title: Downlights; Manufacturer: N/A
Electrical - Ballast Voltage: 1291.67; Ballast Number of Poles: 1; Wattage Comments: 32; Load Classification: Lighting - Dwelling Unit; Lamp: T8, 1219mm, RAPID START, CRI=75
Name (M_Troffer Light - Parabolic Rectangular:B1D - 0610x1219mm:B1D - 0610x1219mm:...) | In
741084 | 1C09
741090 | 1C09
741098 | 1C08
741104 | 1C08

# IfcFlowTerminal: B3 - 610x610mm (96)
Type - ElementType: B3 - 610x610mm; Classification:  (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Glass - White, High Luminance, Metal - Chrome
Other - SerialNumber: N/A; TagNumber: N/A; FixtureHeight: 0; WarrantyStartDate: N/A; Reference: REF TYPE MARK; BarCode: N/A; AssetIdentifier: N/A; BackupSupplySystem: NO; InstallationDate: N/A; RatedCurrent: 0; AccessibilityPerformance: N/A; CodePerformance: N/A; Size: 0; ConductorFunction: L1; WarrantyGuarantorParts: N/A; NumberOfSources: 0; IP_Code: 0; NominalWidth: 0; ExpectedLife: N/A; Features: N/A; AssetAccountingType: FIXED; WarrantyDurationLabor: N/A; WarrantyDescription: N/A; SustainabilityPerformance: N/A; WarrantyDurationParts: N/A; MaximumSpaceSensibleLoad: 0; MaximumPlenumSensibleLoad: 0; HasProtectiveEarth: TRUE; WarrantyGuarantorLabor: N/A; NominalFrequencyRange: 0; NominalHeight: 0; TotalWattage: 0; NumberOfPoles: 0; Shape: N/A; NominalLength: 0; ReplacementCost: N/A; ProductionYear: N/A; Material: N/A; ModelLabel: N/A; Constituents: N/A; SensibleLoadToRadiant: 0; ModelReference: N/A; PowerFactor: 0; Grade: N/A; MaintenanceFactor: 0; RatedVoltage: 0
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-40 VA
Phasing - Phase Created: New Construction
Constraints - Elevation: 2.68 m; Default Elevation: 1.2 m
Electrical - Loads - Apparent Load: 430.556
Dimensions - Light Source Symbol Size: 0.05 m
Identity Data - Manufacturer: N/A; OmniClass Number: 23.80.70.11.14.11; Description: 610mm X 610MM (NOMIMAL) RECESSED TROFFER. A-12 PRISMATIC LENS, BAKED WHITE ENAMEL FINISH.; OmniClass Title: Downlights; Type Mark: B3
Electrical - Lamp: U-SHAPED, CRI=75; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67; Wattage Comments: 32; Ballast Number of Poles: 1
Photometrics - Dimming Lamp Color Temperature Shift: 0; Light Loss Factor: 0; Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Initial Intensity: 0; Lumens: 3150; Color Filter: 16777215
Materials and Finishes - Grid Material: Metal - Paint Finish - Dark Gray, Matte; Diffuser Material: Glass - White, High Luminance; Light Box Material: Metal - Chrome
Name (M_Troffer Light - Parabolic Square:B3 - 610x610mm:B3 - 610x610mm:...) | In | Schedule Level | Panel | Circuit Number | Host
742765 | 1AC2 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743013 | 1AC3 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743021 | 1AC3 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743047 | 1CC1 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743053 | 1CC1 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743069 | 1CC1 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743077 | 1CC1 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743093 | 1CC3 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743109 | 1C12 | Level: Level 1 | L41C | 4 | Linked Revit Model : Clinic_A.rvt
743206 | 1CC1 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743218 | 1DC4 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743226 | 1DC3 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743242 | 1DC3 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743258 | 1DC3 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743268 | 1DC3 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
743276 | 1D04 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
743292 | 1D01 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
743364 | 1DC1 | Level: Level 1 | L41C | 6 | Linked Revit Model : Clinic_A.rvt
743372 | 1DC1 | Level: Level 1 | L41C | 6 | Linked Revit Model : Clinic_A.rvt
743390 | 1D26 | Level: Level 1 | L41B | 5 | Linked Revit Model : Clinic_A.rvt
743400 | 1DC6 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
743418 | 1DC7 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
743426 | 1DC7 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
743442 | 1DC7 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
743450 | 1DC7 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
743460 | 1DC6 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
743476 | 1EC3 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743484 | 1E10 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
743492 | 1E09 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
743508 | 1EC1 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743516 | 1EC1 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743534 | 1EC1 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743544 | 1EC1 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743562 | 1EC1 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743570 | 1EC1 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743594 | 1BC4 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743612 | 1BC4 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743620 | 1BC4 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743642 | 1BC4 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743650 | 1BC3 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743666 | 1BC3 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743678 | 1BC2 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743698 | 1B11 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
743708 | 1B05 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
743718 | 1BC2 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743726 | 1BC2 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743756 | 1B02 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
743885 | 1AC5 | Level: Level 1 | L41C | 1 | Linked Revit Model : Clinic_A.rvt
743903 | 1EC2 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
743919 | 1EC4 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
746231 | 1E12 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
756022 | 2A01 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
756270 | 2A01 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
756279 | 2A01 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
756287 | 2A01 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
756355 | 2A01 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
756391 | 2AC4 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756409 | 2AC4 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756437 | 2AC3 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756447 | 2AC3 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756467 | 2CC2 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756475 | 2CC2 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756501 | 2CC3 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756511 | 2CC3 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756529 | 2CC5 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756551 | 2CC1 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756573 | 2CC1 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
756589 | 2DC2 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756597 | 2DC2 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756613 | 2DC2 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756621 | 2DC2 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756639 | 2DC1 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756647 | 2DC1 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756663 | 2DC1 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756679 | 2BC2 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756687 | 2BC2 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756717 | 2BC3 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756735 | 2BC3 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756747 | 2B22 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
756757 | 2BC4 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756777 | 2BC5 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756795 | 2BC5 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756805 | 2BC5 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
756823 | 2BC6 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
757715 | 2CC4 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
762463 | 2AC5 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
762706 | 2AC2 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
762938 | 2C03 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
769856 | 2D13 | Level: Level 2 | L42B | 6 | <not associated>
773813 | 2B6 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
773823 | 2B5 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
