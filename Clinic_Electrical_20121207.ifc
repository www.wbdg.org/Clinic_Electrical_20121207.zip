Properties of the parts of a building model (IFC2X3), part 7 of 7

# IfcFlowTerminal: Standard (958)
Name (M_Duplex Receptacle:Standard:Standard:...) | In | Schedule Level | Elevation (m) | Host | Circuit Number | Panel | Mark
962214 | 2D07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22B | 729
962257 | 2D07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22B | 730
962322 | 2D07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22B | 731
962438 | 2D07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22B | 732
962764 | 2D06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22B | 733
962838 | 2D06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22B | 734
962891 | 2D06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22B | 735
963035 | 2D06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22B | 736
963199 | 2D06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22B | 737
963263 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22B | 738
964031 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22B | 739
964679 | 2D21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 29 | N22B | 740
965014 | 2BC3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22B1 | 741
965276 | 2DC2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22B | 742
965324 | 2D05 | Level: Level 2 | 0.5 | Grid : 6 | 24 | N22C1 | 743
965367 | 2D05 | Level: Level 2 | 0.5 | Grid : 6 | 24 | N22C1 | 744
965754 | 2D05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22C1 | 745
965877 | 2D05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 24 | N22C1 | 746
965919 | 2R02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22C1 | 747
965999 | 2D05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 24 | N22C1 | 748
966466 | 2A09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C | 749
966520 | 2A09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22C | 750
966604 | 2A09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22C | 751
966657 | 2A09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22C | 752
966700 | 2A09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22C | 753
966743 | 2A09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22C | 754
966806 | 2A09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22C | 755
966860 | 2A09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22C | 756
966903 | 2A08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C | 757
966956 | 2A08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C | 758
967029 | 2A08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C | 759
967072 | 2A08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C | 760
967115 | 2A08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C | 761
967264 | 2A08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22C | 762
967282 | 2A08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C | 763
967336 | 2A08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C | 764
967399 | 2A07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C | 765
967484 | 2A07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C | 766
967527 | 2A07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22C | 767
967722 | 2A07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C | 768
967765 | 2A07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C | 769
967808 | 2A07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C | 770
967851 | 2A07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C | 771
967904 | 2A06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C | 772
967948 | 2A06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C | 773
967991 | 2A06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C | 774
968034 | 2A06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22C | 775
968221 | 2A06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C | 776
968264 | 2A06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C | 777
968307 | 2A06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C | 778
968361 | 2A06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C | 779
968545 | 2A05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C | 780
968609 | 2A05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C | 781
968652 | 2A05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C | 782
968746 | 2A05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C | 783
968869 | 2A05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C | 784
968922 | 2A05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22C | 785
969066 | 2A05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C | 786
969110 | 2A05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C | 787
969153 | 2A04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C | 788
969456 | 2A04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C | 789
969530 | 2A04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C | 790
969655 | 2A04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C | 791
969708 | 2A04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C | 792
969751 | 2A03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22C | 793
969815 | 2A03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22C | 794
969960 | 2A03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22C | 795
970053 | 2AC3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C | 796
970097 | 2A03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22C | 797
970325 | 2A03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22C | 798
970368 | 2A02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22C | 799
970411 | 2A02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22C | 800
970465 | 2A02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22C | 801
970625 | 2AC4 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C | 802
970644 | 2A13 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22C | 803
970688 | 2A13 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N22C | 804
970955 | 2A13 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 22 | N22C | 805
971069 | 2A13 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 18 | N22C | 806
971124 | 2A13 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 18 | N22C | 807
971197 | 2A13 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 22 | N22C | 808
971271 | 2A13 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 18 | N22C | 809
971326 | 2A02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22C | 810
971564 | 2A02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22C | 811
971607 | 2A01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22C | 812
971661 | 2A01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22C | 813
971725 | 2A01 | Level: Level 2 | 0.5 | M_Lighting Switches : Single Pole | 16 | N22C | 814
971891 | 2A01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22C | 815
972105 | 2A01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22C | 816
972179 | 2A01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22C | 817
972222 | 2A14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22C | 818
972325 | 2A14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22C | 819
972368 | 2A14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N22C | 820
972787 | 2A14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22C | 821
972885 | 2A14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22C | 822
972938 | 2A14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22C | 823
972981 | 2A14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22C | 824
973064 | 2A14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22C | 825
973128 | 2AC5 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C | 826
973214 | 2A11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22C | 827
973465 | 2A11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22C | 828
973528 | Level 2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22C | 829
973729 | 2A11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22C | 830
973848 | 2A11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22C | 831
973922 | 2A12-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22C | 832
974049 | 2A12 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 24 | N22C | 833
974092 | 2A12 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22C | 834
974147 | 2A12 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22C | 835
974284 | 2A12-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22C | 836
974338 | 2AC3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C | 837
974453 | 2A11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22C | 838
974529 | 2A10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22C | 839
974635 | 2A10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22C | 840
974823 | 2AC2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22C | 841
974844 | 2C02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22C1 | 842
975160 | 2C02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22C1 | 843
975214 | 2C02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22C1 | 844
975278 | 2C02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22C1 | 845
975342 | 2C02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22C1 | 846
975436 | 2C02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22C1 | 847
975489 | 2C02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22C1 | 848
975543 | 2C04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C1 | 849
975608 | 2C04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C1 | 850
975662 | 2C04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C1 | 851
975706 | 2C04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C1 | 852
975800 | 2C04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C1 | 853
975836 | 2C04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C1 | 854
975867 | 2C06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22C1 | 855
975922 | 2C06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22C1 | 856
975969 | 2C04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C1 | 857
976048 | 2C04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C1 | 858
976091 | 2C06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22C1 | 859
976144 | 2C06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22C1 | 860
976209 | 2C06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22C1 | 861
976407 | 2C06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22C1 | 862
976460 | 2C06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22C1 | 863
976503 | 2C06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22C1 | 864
976546 | 2C06 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22C1 | 865
976669 | 2C09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C1 | 866
976733 | 2C09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C1 | 867
976776 | 2C09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22C1 | 868
976830 | 2C09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C1 | 869
976955 | 2C09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C1 | 870
976998 | 2C09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C1 | 871
977061 | 2C09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C1 | 872
977104 | 2C09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C1 | 873
977267 | 2C11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C1 | 874
977304 | 2CC4 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22C1 | 875
977385 | 2CS3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22C1 | 876
977577 | 2CC4 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22C1 | 877
977618 | 2C13 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C1 | 878
977660 | 2C14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22C1 | 879
977697 | 2C14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22C1 | 880
977721 | 2C14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22C1 | 881
977764 | 2C14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 23 | N22C1 | 882
977939 | 2C14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22C1 | 883
978023 | 2C14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22C1 | 884
978116 | 2C14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22C1 | 885
978159 | 2C14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22C1 | 886
978292 | 2C16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C1 | 887
978335 | 2C16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22C1 | 888
978378 | 2C16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 6 | N22C1 | 889
978421 | 2C16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N22C1 | 890
978607 | 2C16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N22C1 | 891
978672 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 18 | N22C1 | 892
978791 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 23 | N22C1 | 893
978855 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 17 | N22C1 | 894
978898 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 16 | N22C1 | 895
979092 | 2C17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 8 | N22C1 | 896
979229 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 22 | N22C1 | 897
979346 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 22 | N22C1 | 898
979389 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 21 | N22C1 | 899
979665 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 19 | N22C1 | 900
979739 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 19 | N22C1 | 901
979782 | 2C17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 8 | N22C1 | 902
979867 | 2C17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 21 | N22C1 | 903
980076 | 2C17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 19 | N22C1 | 904
980242 | 2C17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 20 | N22C1 | 905
980326 | 2C17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 8 | N22C1 | 906
980380 | 2C17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22C1 | 907
980434 | 2C17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22C1 | 908
980932 | 2D05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22C1 | 909
981238 | 2D05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22C1 | 910
981334 | 2CC1 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22C1 | 911
981419 | 2C18 | Level: Level 2 | 0.5 | M_Lighting and Appliance Panelboard - 208V MLO : L42C | 16 | N22C1 | 912
981750 | 2C19 | Level: Level 2 | 0.5 | M_Lighting and Appliance Panelboard - 208V MLO : N22C2 | 12 | N22C1 | 913
981867 | 2C19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C1 | 914
981931 | 2C19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C1 | 915
982005 | 2C19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22C1 | 916
982205 | 2C19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C1 | 917
982349 | 2C19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C1 | 918
982423 | 2C19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C1 | 919
982476 | 2C10 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 14 | N22C1 | 920
982591 | 2C10 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 14 | N22C1 | 921
982853 | 2C10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22C1 | 922
983014 | 2C12 | Level: Level 2 | 0.5 | Orphaned | 16 | N22C1 | 923
983550 | 2C12 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 16 | N22C1 | 924
983707 | 2C12 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 14 | N22C1 | 925
983750 | 2C12 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C1 | 926
983805 | 2C12 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22C1 | 927
983891 | 2C10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22C1 | 928
984323 | 2CC3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C | 929
984429 | 2CC1 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22C1 | 930
984619 | 2C08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C1 | 931
984742 | 2C07 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C1 | 932
984796 | 2C22 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22C1 | 933
985250 | 2C22 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22C1 | 934
985333 | 2C22 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22C1 | 935
985491 | 2C22 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22C1 | 936
985665 | 2C22 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22C1 | 937
985718 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22C1 | 938
985792 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22C1 | 939
985846 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22C1 | 940
986060 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22C1 | 941
986091 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22C1 | 942
986279 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22C1 | 943
986333 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22C1 | 944
986534 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C1 | 945
986648 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22C1 | 946
986691 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C1 | 947
986836 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C1 | 948
986899 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22C1 | 949
987056 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C1 | 950
987109 | 2C03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22C1 | 951
987153 | 2C05 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22C1 | 952
987258 | 2C01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C1 | 953
987374 | 2C01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C1 | 954
987418 | 2C01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C1 | 955
987472 | 2C01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C1 | 956
987610 | 2C01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22C1 | 957
987663 | 2C23 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C2 | 958
987890 | Level 2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22C | 959
987945 | Level 2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22C2 | 960
988850 | 2CC3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C | 961
988882 | 2CC2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22C | 962
989814 | 2C15 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22C1 | 963

# IfcFlowTerminal: T1 (8)
Type - ElementType: T1; Classification: D5020220 Lighting - Incandescent (UniFormat)
Material: Glass - Frosted
Materials and Finishes - Shade Material: Glass - Frosted
Constraints - Default Elevation: 1.9 m
Electrical - Loads - Apparent Load: 1076.39; Panel: L41C
Photometrics - Color Filter: 16777215; Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Dimming Lamp Color Temperature Shift: 0; Initial Intensity: 0; Light Loss Factor: 0; Lumens: 2900
Dimensions - Light Source Symbol Size: 0.05 m; Radius: 0.2 m
Electrical - Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Ballast Voltage: 1291.67; Lamp: -
Identity Data - OmniClass Title: General Luminaries, Non Directional; Description: LINEAR WALL MOUNTED UPLIGHT; OmniClass Number: 23.80.70.11.11; Assembly Code: D5020220; Assembly Description: Lighting - Incandescent; Manufacturer: N/A; Type Mark: T1
Other - Grade: N/A; WarrantyDescription: N/A; ProductionYear: N/A; ReplacementCost: N/A; HasProtectiveEarth: TRUE; SensibleLoadToRadiant: 0; WarrantyGuarantorParts: N/A; NominalLength: 0; ModelReference: N/A; NominalWidth: 0; Material: N/A; MaximumPlenumSensibleLoad: 0; MaximumSpaceSensibleLoad: 0; ExpectedLife: N/A; NominalHeight: 0; WarrantyDurationLabor: N/A; NumberOfPoles: 0; ConductorFunction: L1; WarrantyDurationParts: N/A; SustainabilityPerformance: N/A; IP_Code: 0; Shape: N/A; TotalWattage: 0; NominalFrequencyRange: 0; RatedVoltage: 0; AssetAccountingType: FIXED; WarrantyGuarantorLabor: N/A; CodePerformance: N/A; Features: N/A; Constituents: N/A; RatedCurrent: 0; NumberOfSources: 0; ModelLabel: N/A; PowerFactor: 0; Size: 0; AccessibilityPerformance: N/A; MaintenanceFactor: 0; SerialNumber: N/A; FixtureHeight: 0; BarCode: N/A; BackupSupplySystem: NO; Schedule Level: Level: Level 1; TagNumber: N/A; WarrantyStartDate: N/A; AssetIdentifier: N/A; InstallationDate: N/A; Reference: REF TYPE MARK
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Name (M_Sconce Light - Sphere:T1:T1:...) | In | Circuit Number | Elevation (m) | Host
752725 | 1AC1 | 7 | 2 | Grid : D.9
752761 | 1AC1 | 7 | 2 | Grid : D.9
753021 | 1AC1 | 7 | 2 | Linked Revit Model : Clinic_A.rvt
753296 | 1AC1 | 7 | 2 | Linked Revit Model : Clinic_A.rvt
927298 | 1DC1 | 8 | 2.5 | <not associated>
927365 | 1DC1 | 8 | 2.5 | <not associated>
927616 | 1DC1 | 8 | 2 | Grid : D.9
927617 | 1DC1 | 8 | 2 | Linked Revit Model : Clinic_A.rvt

# IfcFlowTerminal: Three Way (4)
Type - ElementType: Three Way; PredefinedType: USERDEFINED; Classification:  (UniFormat)
Electrical - Loads - Apparent Load: 0
Constraints - Default Elevation: 1.2 m; Elevation: 1.2 m; Offset: 0 m
Electrical - Load Classification: Other; Switch Voltage: 1291.67
Identity Data - Manufacturer: N/A; Label: 3; OmniClass Number: 23.80.50.11.14; OmniClass Title: Switches
Other - NumberOfPoles: 0; ConductorFunction: L1; NominalWidth: 0; IP_Code: 0; PowerFactor: 0; RatedVoltage: 0; WarrantyDurationParts: N/A; WarrantyGuarantorLabor: N/A; ModelReference: N/A; NominalLength: 0; NominalFrequencyRange: 0; WarrantyDescription: N/A; CodePerformance: N/A; ProductionYear: N/A; ExpectedLife: N/A; Shape: N/A; HasProtectiveEarth: TRUE; SustainabilityPerformance: N/A; ReplacementCost: N/A; RatedCurrent: 0; AccessibilityPerformance: N/A; Size: 0; WarrantyGuarantorParts: N/A; Constituents: N/A; WarrantyDurationLabor: N/A; Material: N/A; ModelLabel: N/A; Grade: N/A; Features: N/A; NominalHeight: 0; AssetAccountingType: FIXED; InstallationDate: N/A; SerialNumber: N/A; TagNumber: N/A; WarrantyStartDate: N/A; Schedule Level: Level: Level 1; AssetIdentifier: N/A; BarCode: N/A
Electrical - Circuiting - Electrical Data: 120 V/1-0 VA
Phasing - Phase Created: New Construction
Name (M_Lighting Switches:Three Way:Three Way:...) | In | Host | Panel | Circuit Number
798387 | 1C18 | Linked Revit Model : Clinic_A.rvt | L41C | 4
798953 | 1C18 | Linked Revit Model : Clinic_A.rvt | L41C | 4
803977 | 1C10 | Linked Revit Model : Clinic_A.rvt | N21C1 | 22
811180 | 1DC1 | Grid : D.9 | L41C | 6

# IfcFlowTerminal: X1 (35)
Type - ElementType: X1; Classification: D5020200 Lighting Equipment (UniFormat)
Material: Paint-Philips Chloride-Black, Plastic-Philips Chloride-Red, Aluminum-Philips Chloride
Materials and Finishes - Lens Material Finish: Plastic-Philips Chloride-Red; Face Plate Material Finish: Aluminum-Philips Chloride; Housing Material Finish: Paint-Philips Chloride-Black
Electrical - Loads - Apparent Load: 40.9029
Photometrics - Photometry Comments: No Photometry Available; Light Source Definition (family): Rectangle+Spherical; Initial Color: 0; Emit from Rectangle Width: 0.225524 m; Light Loss Factor: 0; Color Filter: 16777215; Emit Shape Visible in Rendering: no; Emit from Rectangle Length: 0.33655 m; Initial Intensity: 0; Dimming Lamp Color Temperature Shift: 0
Dimensions - Depth: 0.12065 m; Light Source Symbol Size: 0.6096 m; Width: 0.33655 m; Length: 0.225524 m
Constraints - Default Elevation: 1.2192 m
Electrical - Voltage Comments: 12/27 (Dual Voltage - 120/277); Lamp: LED; Voltage: 1291.67
Other - MaximumPlenumSensibleLoad: 0; Grade: N/A; ProductionYear: N/A; IP_Code: 0; ConductorFunction: L1; PowerFactor: 0; Constituents: N/A; CodePerformance: N/A; Shape: N/A; RatedCurrent: 0; RatedVoltage: 0; MaximumSpaceSensibleLoad: 0; HasProtectiveEarth: TRUE; NumberOfPoles: 0; ReplacementCost: N/A; ExpectedLife: N/A; NominalLength: 0; WarrantyDescription: N/A; WarrantyDurationParts: N/A; NumberOfSources: 0; Features: N/A; NominalWidth: 0; ModelLabel: N/A; SustainabilityPerformance: N/A; MaintenanceFactor: 0; WarrantyGuarantorParts: N/A; TotalWattage: 0; AssetAccountingType: FIXED; SensibleLoadToRadiant: 0; AccessibilityPerformance: N/A; NominalHeight: 0; WarrantyDurationLabor: N/A; WarrantyGuarantorLabor: N/A; ModelReference: N/A; Material: N/A; NominalFrequencyRange: 0; Size: 0; AssetIdentifier: N/A; WarrantyStartDate: N/A; BackupSupplySystem: NO; FixtureHeight: 0; SerialNumber: N/A; InstallationDate: N/A; BarCode: N/A; TagNumber: N/A; Reference: REF TYPE MARK
Data - Spacing to Mounting Height Ratio Diagonal: Not Available; Spacing to Mounting Height Ratio 90 Degree Plane: Not Available; CIE Type: Not Available; Housing Finish Option: Matte Black w/Brushed Aluminum Face; NEMA Type: Not Applicable; LER Luminaire Efficacy Rating: Not Available; Fixture Efficiency: Not Available; Number of Lamps or LEDs: 16; Spacing to Mounting Height Ratio 0 Degree Plane: Not Available; Lens Option: Red; Lamp Position: Horizontal; Number of Faces: 1
Identity Data - Type Mark: X1; Product Family: 55 Line LED Die Cast Aluminum Exit - Traditional; Catalog Number: 55LA-1-12/27-R; OmniClass Number: 23.80.70.11.21; Model: 55LA-1-12/27-R; Specification Sheet: CE-11400; Product Page URL: http://www.chloridesys.com/chloride/Chloridefixture.cfm?ID=3748; Assembly Code: D5020200; URL: http://www.chloridesys.com/chloride/; Description: 55 Line Traditional Exit, Ceiling Mounted; Assembly Description: Lighting Equipment; OmniClass Title: Emergency Lighting; Manufacturer: N/A
Electrical - Circuiting - Electrical Data: Luminaire 120 V/1-4 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Name (Exit Sign - Ceiling_Mount_Single:X1:X1:...) | In | Host | Elevation (m) | Schedule Level
1213762 | 2DC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1213637 | 2D18 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1213375 | 2DC2 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1213197 | 2CC2 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1213038 | 2CC4 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1212926 | 2BC5 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1212883 | 2BC6 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1207392 | 1AC5 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1207471 | 1AC3 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1207638 | 1BC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1207752 | 1BC2 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1207902 | 1AC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1208041 | 1BC3 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1208270 | 1BC4 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1208340 | Level 1 | Grid : B | 1.2192 | Level: Level 1
1208478 | 1CC3 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1208512 | 1CC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1208717 | 1CC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1209019 | 1DC4 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1209106 | 1DC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1209371 | 1DC2 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1209672 | 1DC6 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1209761 | 1EC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1210348 | 1DC5 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1210426 | 1DC7 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1210975 | 1EC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1211011 | 1EC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1211262 | 1EC1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 1
1211360 | 2AC4 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1211434 | 2AC4 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1211562 | 2A11 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1212024 | 2BC3 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1212137 | 2BC3 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1212229 | 2BC2 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2
1212330 | 2BC2 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level: Level 2

# IfcFlowTerminal: X1B (2)
Type - ElementType: X1B; Classification: D5020200 Lighting Equipment (UniFormat)
Material: Paint-Philips Chloride-Black, Plastic-Philips Chloride-Red, Aluminum-Philips Chloride
Materials and Finishes - Lens Material Finish: Plastic-Philips Chloride-Red; Face Plate Material Finish: Aluminum-Philips Chloride; Housing Material Finish: Paint-Philips Chloride-Black
Constraints - Default Elevation: 1.2192 m; Host: Linked Revit Model : Clinic_A.rvt
Identity Data - Model: 55LA-2-12/27-R; OmniClass Title: Emergency Lighting; Product Family: 55 Line LED Die Cast Aluminum Exit - Traditional; Catalog Number: 55LA-2-12/27-R; Specification Sheet: CE-11400; Assembly Code: D5020200; OmniClass Number: 23.80.70.11.21; Product Page URL: http://www.chloridesys.com/chloride/Chloridefixture.cfm?ID=3748; URL: http://www.chloridesys.com/chloride/; Assembly Description: Lighting Equipment; Description: 55 Line Traditional Exit, End Mounted; Manufacturer: N/A; Type Mark: X1B
Electrical - Loads - Apparent Load: 40.9029
Data - Spacing to Mounting Height Ratio Diagonal: Not Available; Number of Lamps or LEDs: 16; NEMA Type: Not Applicable; Housing Finish Option: Matte Black w/Brushed Aluminum Face; Fixture Efficiency: Not Available; LER Luminaire Efficacy Rating: Not Available; CIE Type: Not Available; Number of Faces: 2; Lens Option: Red; Spacing to Mounting Height Ratio 0 Degree Plane: Not Available; Spacing to Mounting Height Ratio 90 Degree Plane: Not Available; Lamp Position: Horizontal
Photometrics - Light Loss Factor: 0; Emit from Rectangle Width: 0.3556 m; Light Source Definition (family): Rectangle+Spherical; Color Filter: 16777215; Photometry Comments: No Photometry Available; Dimming Lamp Color Temperature Shift: 0; Initial Intensity: 0; Emit Shape Visible in Rendering: no; Initial Color: 0; Emit from Rectangle Length: 0.206474 m
Electrical - Voltage: 1291.67; Lamp: LED; Voltage Comments: 12/27 (Dual Voltage - 120/277)
Dimensions - Depth: 0.12065 m; Length: 0.206474 m; Light Source Symbol Size: 0.6096 m; Width: 0.3556 m
Other - Material: N/A; Constituents: N/A; WarrantyGuarantorParts: N/A; NominalFrequencyRange: 0; RatedCurrent: 0; Size: 0; RatedVoltage: 0; Grade: N/A; NominalWidth: 0; NumberOfSources: 0; ModelReference: N/A; NominalHeight: 0; AssetAccountingType: FIXED; TotalWattage: 0; WarrantyGuarantorLabor: N/A; HasProtectiveEarth: TRUE; NumberOfPoles: 0; MaximumSpaceSensibleLoad: 0; ReplacementCost: N/A; WarrantyDurationParts: N/A; Features: N/A; NominalLength: 0; ModelLabel: N/A; ExpectedLife: N/A; ProductionYear: N/A; CodePerformance: N/A; SensibleLoadToRadiant: 0; PowerFactor: 0; MaximumPlenumSensibleLoad: 0; SustainabilityPerformance: N/A; WarrantyDescription: N/A; ConductorFunction: L1; IP_Code: 0; AccessibilityPerformance: N/A; Shape: N/A; MaintenanceFactor: 0; WarrantyDurationLabor: N/A; BackupSupplySystem: NO; SerialNumber: N/A; WarrantyStartDate: N/A; TagNumber: N/A; FixtureHeight: 0; BarCode: N/A; InstallationDate: N/A; Reference: REF TYPE MARK; Schedule Level: Level: Level 2; AssetIdentifier: N/A
Electrical - Circuiting - Electrical Data: Luminaire 120 V/1-4 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Name (Exit Sign - End Mount - Double Face:X1B:X1B:...) | In | Elevation (m)
1213538 | 2D05 | 2.134
1212490 | 2BC1 | 1.2192

# IfcFlowTerminal: X2 (6)
Type - ElementType: X2; Classification: D5020200 Lighting Equipment (UniFormat)
Material: Paint-Philips Chloride-Black, Plastic-Philips Chloride-Green, Aluminum-Philips Chloride
Constraints - Default Elevation: 1.2192 m; Elevation: 2.68 m; Host: Linked Revit Model : Clinic_A.rvt
Materials and Finishes - Lens Material Finish: Plastic-Philips Chloride-Green; Face Plate Material Finish: Aluminum-Philips Chloride; Housing Material Finish: Paint-Philips Chloride-Black
Electrical - Loads - Apparent Load: 43.0556
Photometrics - Photometry Comments: No Photometry Available; Color Filter: 16777215; Emit from Rectangle Width: 0.225524 m; Light Source Definition (family): Rectangle+Spherical; Light Loss Factor: 0; Initial Intensity: 0; Emit Shape Visible in Rendering: no; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Emit from Rectangle Length: 0.33655 m
Dimensions - Length: 0.225524 m; Width: 0.33655 m; Light Source Symbol Size: 0.6096 m; Depth: 0.12065 m
Electrical - Voltage Comments: 12/27 (Dual Voltage - 120/277); Lamp: LED; Voltage: 1291.67
Data - LER Luminaire Efficacy Rating: Not Available; Lens Option: Green; Fixture Efficiency: Not Available; Housing Finish Option: Matte Black w/Brushed Aluminum Face; Spacing to Mounting Height Ratio 90 Degree Plane: Not Available; Spacing to Mounting Height Ratio 0 Degree Plane: Not Available; CIE Type: Not Available; NEMA Type: Not Applicable; Lamp Position: Horizontal; Number of Faces: 2; Number of Lamps or LEDs: 11; Spacing to Mounting Height Ratio Diagonal: Not Available
Other - TotalWattage: 0; NumberOfPoles: 0; Constituents: N/A; MaintenanceFactor: 0; Shape: N/A; MaximumPlenumSensibleLoad: 0; ExpectedLife: N/A; RatedVoltage: 0; CodePerformance: N/A; AccessibilityPerformance: N/A; NominalFrequencyRange: 0; Features: N/A; WarrantyDurationLabor: N/A; PowerFactor: 0; ReplacementCost: N/A; NominalWidth: 0; AssetAccountingType: FIXED; ModelReference: N/A; MaximumSpaceSensibleLoad: 0; NominalHeight: 0; ProductionYear: N/A; Grade: N/A; ModelLabel: N/A; NumberOfSources: 0; Material: N/A; Size: 0; WarrantyGuarantorLabor: N/A; ConductorFunction: L1; NominalLength: 0; RatedCurrent: 0; HasProtectiveEarth: TRUE; IP_Code: 0; SustainabilityPerformance: N/A; WarrantyDescription: N/A; WarrantyGuarantorParts: N/A; WarrantyDurationParts: N/A; SensibleLoadToRadiant: 0; BackupSupplySystem: NO; Reference: REF TYPE MARK; WarrantyStartDate: N/A; AssetIdentifier: N/A; TagNumber: N/A; FixtureHeight: 0; BarCode: N/A; SerialNumber: N/A; InstallationDate: N/A
Identity Data - Product Page URL: http://www.chloridesys.com/chloride/Chloridefixture.cfm?ID=3748; Product Family: 55 Line LED Die Cast Aluminum Exit - Traditional; URL: http://www.chloridesys.com/chloride/; Catalog Number: 55LA-2-12/27-G; OmniClass Number: 23.80.70.11.21; Model: 55LA-2-12/27-G; Specification Sheet: CE-11400; OmniClass Title: Emergency Lighting; Manufacturer: N/A; Assembly Description: Lighting Equipment; Type Mark: X2; Assembly Code: D5020200; Description: 55 Line Traditional Exit, Ceiling Mounted
Electrical - Circuiting - Electrical Data: Luminaire 120 V/1-4 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Name (Exit Sign - Ceiling_Mount_Double Face:X2:X2:...) | In | Schedule Level
1213090 | 2CC4 | Level: Level 2
1209531 | 1DC3 | Level: Level 1
1210221 | 1DC1 | Level: Level 1
1210672 | 1DC7 | Level: Level 1
1210838 | 1DC1 | Level: Level 1
1211822 | 2AC3 | Level: Level 2

# IfcFlowTerminal: Y - X-Ray (3)
Type - ElementType: Y - X-Ray; Classification:  (UniFormat)
Material: Default Light Source
Visibility - XRAY: yes; DARKROOM: no
Electrical - Lamp: T4, TWIN TUBE CRI=75
Identity Data - Manufacturer: N/A; OmniClass Title: Lighting; Type Mark: Y; Description: SURFACE FLOURESCENT INDICATING TYPE FIXTURE HAVING 51mm HIGH LETTERS "X-RAY IN USE"; OmniClass Number: 23.80.70.00
Dimensions - Elevation: 2.5845 m; Light Source Symbol Size: 0.6096 m
Other - MaintenanceFactor: 0; ModelLabel: N/A; Size: 0; SensibleLoadToRadiant: 0; NumberOfPoles: 0; AssetAccountingType: FIXED; Features: N/A; WarrantyDurationParts: N/A; NominalHeight: 0; TotalWattage: 0; PowerFactor: 0; CodePerformance: N/A; HasProtectiveEarth: TRUE; RatedVoltage: 0; MaximumPlenumSensibleLoad: 0; AccessibilityPerformance: N/A; Material: N/A; ConductorFunction: L1; ReplacementCost: N/A; WarrantyDurationLabor: N/A; ModelReference: N/A; NumberOfSources: 0; Grade: N/A; SustainabilityPerformance: N/A; Shape: N/A; ExpectedLife: N/A; NominalFrequencyRange: 0; ProductionYear: N/A; MaximumSpaceSensibleLoad: 0; WarrantyGuarantorParts: N/A; Constituents: N/A; RatedCurrent: 0; WarrantyGuarantorLabor: N/A; NominalLength: 0; IP_Code: 0; WarrantyDescription: N/A; NominalWidth: 0; TagNumber: N/A; InstallationDate: N/A; BarCode: N/A; SerialNumber: N/A; WarrantyStartDate: N/A; Reference: REF TYPE MARK; AssetIdentifier: N/A; FixtureHeight: 0; BackupSupplySystem: NO
Photometrics - Initial Color: 0; Initial Intensity: 0; Color Filter: 16777215; Light Loss Factor: 0; Light Source Definition (family): Point+Spherical; Dimming Lamp Color Temperature Shift: 0
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Constraints - Offset: 0 m; Moves With Nearby Elements: no
Name (Lighted Signage:Y - X-Ray:Y - X-Ray:...) | In | Host | Level | Mark
1220125 | 2AC3 | Level : Level 2 | Level: Level 2 | Y50
1214966 | 1BC2 | Level : Level 1 | Level: Level 1 | Y48
1214885 | 1B17 | Level : Level 1 | Level: Level 1 | Y47

# IfcFlowTerminal: Y1 - Darkroom, Lighted Signage:Y1 - Darkroom:Y1 - Darkroom:1220034
In: 2A12
Type - ElementType: Y1 - Darkroom; Classification:  (UniFormat)
Electrical - Lamp: T4, TWIN TUBE CRI=75
Visibility - XRAY: no; DARKROOM: yes
Identity Data - Type Mark: Y1; Description: SURFACE FLOURESCENT INDICATING TYPE FIXTURE HAVING 51mm HIGH LETTERS "DARKROOM IN USE"; OmniClass Title: Lighting; Manufacturer: N/A; OmniClass Number: 23.80.70.00
Photometrics - Light Loss Factor: 0; Color Filter: 16777215; Initial Color: 0; Light Source Definition (family): Point+Spherical; Initial Intensity: 0; Dimming Lamp Color Temperature Shift: 0
Other - NominalLength: 0; NumberOfPoles: 0; MaximumSpaceSensibleLoad: 0; WarrantyGuarantorParts: N/A; AccessibilityPerformance: N/A; Size: 0; Features: N/A; SensibleLoadToRadiant: 0; NominalWidth: 0; ConductorFunction: L1; RatedVoltage: 0; NominalHeight: 0; CodePerformance: N/A; Shape: N/A; Constituents: N/A; TotalWattage: 0; SustainabilityPerformance: N/A; PowerFactor: 0; MaximumPlenumSensibleLoad: 0; WarrantyDurationLabor: N/A; WarrantyDurationParts: N/A; ProductionYear: N/A; NominalFrequencyRange: 0; ModelLabel: N/A; ReplacementCost: N/A; HasProtectiveEarth: TRUE; MaintenanceFactor: 0; Grade: N/A; AssetAccountingType: FIXED; RatedCurrent: 0; NumberOfSources: 0; ExpectedLife: N/A; WarrantyGuarantorLabor: N/A; ModelReference: N/A; WarrantyDescription: N/A; IP_Code: 0; Material: N/A; InstallationDate: N/A; AssetIdentifier: N/A; FixtureHeight: 0; BackupSupplySystem: NO; BarCode: N/A; Reference: REF TYPE MARK; WarrantyStartDate: N/A; SerialNumber: N/A; TagNumber: N/A
Dimensions - Light Source Symbol Size: 0.6096 m; Elevation: 2.5845 m
Phasing - Phase Created: New Construction
Constraints - Offset: 0 m; Host: Level : Level 2; Moves With Nearby Elements: no; Level: Level: Level 2
Electrical - Lighting - Calculate Coefficient of Utilization: no

# IfcFlowTerminal: Y2, M_Surface Mounted Light:Y2:Y2:760903
In: 2A13
Type - ElementType: Y2; Classification:  (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Dimensions - Light Casing Length: 1.219 m; Drop From Ceiling: 0.1 m; Light Source Symbol Size: 0.05 m
Materials and Finishes - Diffuser Material: Glass - White, High Luminance; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy; Light Casing Material: Metal - Paint Finish - Ivory, Glossy
Photometrics - Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215; Light Loss Factor: 0; Light Source Definition (family): Point+HemiSpherical; Lumens: 2900; Initial Color: 0; Initial Intensity: 0
Electrical - Loads - Apparent Load: 1614.59; Circuit Number: 7; Panel: L42C
Constraints - Default Elevation: 1.2 m; Elevation: 2.68 m; Host: Linked Revit Model : Clinic_A.rvt
Electrical - Ballast Voltage: 1291.67; Lamp: INCANDESCENT; Wattage Comments: 1 - 15; Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit
Identity Data - Description: SINGLE COMPARTMENT DARK ROOM SAFE LIGHT: FILTERED COMPARTMENT, CEILING MOUNTED; OmniClass Number: 23.80.70.11.11; Manufacturer: N/A; OmniClass Title: General Luminaries, Non Directional; Type Mark: Y2
Other - Grade: N/A; IP_Code: 0; SensibleLoadToRadiant: 0; WarrantyDescription: N/A; MaintenanceFactor: 0; MaximumPlenumSensibleLoad: 0; PowerFactor: 0; NominalWidth: 0; NominalHeight: 0; HasProtectiveEarth: TRUE; ExpectedLife: N/A; WarrantyDurationLabor: N/A; Material: N/A; RatedCurrent: 0; AssetAccountingType: FIXED; MaximumSpaceSensibleLoad: 0; RatedVoltage: 0; SustainabilityPerformance: N/A; NumberOfPoles: 0; ProductionYear: N/A; Shape: N/A; ModelLabel: N/A; ConductorFunction: L1; NominalLength: 0; ModelReference: N/A; Size: 0; NominalFrequencyRange: 0; CodePerformance: N/A; NumberOfSources: 0; ReplacementCost: N/A; AccessibilityPerformance: N/A; WarrantyDurationParts: N/A; Features: N/A; TotalWattage: 0; WarrantyGuarantorParts: N/A; Constituents: N/A; WarrantyGuarantorLabor: N/A; Reference: REF TYPE MARK; BackupSupplySystem: NO; TagNumber: N/A; BarCode: N/A; SerialNumber: N/A; AssetIdentifier: N/A; Schedule Level: Level: Level 2; WarrantyStartDate: N/A; InstallationDate: N/A; FixtureHeight: 0
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-150 VA
