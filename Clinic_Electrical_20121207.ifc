Properties of the parts of a building model (IFC2X3), part 4 of 7

# IfcFlowTerminal: B3 - 610x610mm (96)
Name (M_Troffer Light - Parabolic Square:B3 - 610x610mm:B3 - 610x610mm:...) | In | Schedule Level | Panel | Circuit Number | Host
784066 | 2BC3 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
809583 | 1CC2 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
810474 | 1D14 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
817515 | 1D39 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
990974 | 1A13 | Level: Level 1 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt

# IfcFlowTerminal: B3B - 610x610mm (54)
Type - ElementType: B3B - 610x610mm; Classification:  (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Glass - White, High Luminance, Metal - Chrome
Other - WarrantyStartDate: N/A; BarCode: N/A; BackupSupplySystem: YES; TagNumber: N/A; InstallationDate: N/A; AssetIdentifier: N/A; Reference: REF TYPE MARK; SerialNumber: N/A; FixtureHeight: 0; MaximumSpaceSensibleLoad: 0; Size: 0; NominalFrequencyRange: 0; WarrantyGuarantorLabor: N/A; SensibleLoadToRadiant: 0; ModelLabel: N/A; Grade: N/A; ExpectedLife: N/A; NominalLength: 0; Shape: N/A; Features: N/A; IP_Code: 0; WarrantyGuarantorParts: N/A; Constituents: N/A; AssetAccountingType: FIXED; SustainabilityPerformance: N/A; AccessibilityPerformance: N/A; TotalWattage: 0; NumberOfPoles: 0; NumberOfSources: 0; WarrantyDescription: N/A; CodePerformance: N/A; MaximumPlenumSensibleLoad: 0; ConductorFunction: L1; RatedCurrent: 0; ProductionYear: N/A; MaintenanceFactor: 0; WarrantyDurationLabor: N/A; Material: N/A; ReplacementCost: N/A; HasProtectiveEarth: TRUE; WarrantyDurationParts: N/A; NominalHeight: 0; RatedVoltage: 0; PowerFactor: 0; NominalWidth: 0; ModelReference: N/A
Electrical - Circuiting - Electrical Data: 120 V/1-40 VA
Phasing - Phase Created: New Construction
Constraints - Host: Linked Revit Model : Clinic_A.rvt; Elevation: 2.68 m; Default Elevation: 1.2 m
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Loads - Apparent Load: 430.556
Dimensions - Light Source Symbol Size: 0.05 m
Materials and Finishes - Diffuser Material: Glass - White, High Luminance; Light Box Material: Metal - Chrome; Grid Material: Metal - Paint Finish - Dark Gray, Matte
Photometrics - Dimming Lamp Color Temperature Shift: 0; Initial Intensity: 0; Light Loss Factor: 0; Initial Color: 0; Color Filter: 16777215; Light Source Definition (family): Point+HemiSpherical; Lumens: 3150
Electrical - Wattage Comments: 32; Ballast Number of Poles: 1; Lamp: U-SHAPED, CRI=75; Ballast Voltage: 1291.67; Load Classification: Lighting - Dwelling Unit
Identity Data - OmniClass Number: 23.80.70.11.14.11; Description: SAME AS B3 EXCEPT WITH EMERGENCY BATTERY PACK; Manufacturer: N/A; OmniClass Title: Downlights; Type Mark: B3B
Name (M_Troffer Light - Parabolic Square:B3B - 610x610mm:B3B - 610x610mm:...) | In | Schedule Level | Circuit Number | Panel
743001 | 1AC2 | Level: Level 1 | 2 | L41C
743029 | 1AC3 | Level: Level 1 | 2 | L41C
743039 | 1CC1 | Level: Level 1 | 2 | L41C
743061 | 1CC1 | Level: Level 1 | 2 | L41C
743085 | 1CC1 | Level: Level 1 | 2 | L41C
743101 | 1CC3 | Level: Level 1 | 2 | L41C
743234 | 1DC3 | Level: Level 1 | 2 | L41C
743250 | 1DC3 | Level: Level 1 | 2 | L41C
743284 | 1DC2 | Level: Level 1 | 2 | L41C
743312 | 1DC4 | Level: Level 1 | 2 | L41C
743354 | 1DC1 | Level: Level 1 | 6 | L41C
743382 | 1DC5 | Level: Level 1 | 6 | L41C
743408 | 1DC7 | Level: Level 1 | 4 | L41B
743434 | 1DC7 | Level: Level 1 | 4 | L41B
743468 | 1DC6 | Level: Level 1 | 4 | L41B
743500 | 1EC1 | Level: Level 1 | 2 | L41B
743526 | 1EC1 | Level: Level 1 | 2 | L41B
743552 | 1EC1 | Level: Level 1 | 2 | L41B
743582 | 1EC1 | Level: Level 1 | 2 | L41B
743602 | 1BC4 | Level: Level 1 | 2 | L41B
743628 | 1BC4 | Level: Level 1 | 2 | L41B
743658 | 1BC3 | Level: Level 1 | 2 | L41B
743688 | 1BC2 | Level: Level 1 | 2 | L41B
743736 | 1BC2 | Level: Level 1 | 2 | L41B
743744 | 1BC1 | Level: Level 1 | 1 | L41B
743875 | 1AC5 | Level: Level 1 | 1 | L41C
743895 | 1EC2 | Level: Level 1 | 2 | L41B
743911 | 1EC4 | Level: Level 1 | 2 | L41B
756354 | 2A01 | Level: Level 2 | 6 | L42C
756401 | 2AC4 | Level: Level 2 | 3 | L42C
756423 | 2AC3 | Level: Level 2 | 3 | L42C
756457 | 2AC3 | Level: Level 2 | 3 | L42C
756483 | 2CC2 | Level: Level 2 | 3 | L42C
756493 | 2CC3 | Level: Level 2 | 3 | L42C
756519 | 2CC4 | Level: Level 2 | 3 | L42C
756541 | 2CC5 | Level: Level 2 | 3 | L42C
756563 | 2CC1 | Level: Level 2 | 3 | L42C
756581 | 2DC2 | Level: Level 2 | 4 | L42B
756605 | 2DC2 | Level: Level 2 | 4 | L42B
756629 | 2DC2 | Level: Level 2 | 4 | L42B
756655 | 2DC1 | Level: Level 2 | 4 | L42B
756671 | 2BC2 | Level: Level 2 | 4 | L42B
756697 | 2BC2 | Level: Level 2 | 4 | L42B
756709 | 2BC3 | Level: Level 2 | 4 | L42B
756727 | 2BC3 | Level: Level 2 | 4 | L42B
756769 | 2BC4 | Level: Level 2 | 4 | L42B
756787 | 2BC5 | Level: Level 2 | 4 | L42B
756813 | 2BC5 | Level: Level 2 | 4 | L42B
756831 | 2BC6 | Level: Level 2 | 4 | L42B
762565 | 2AC5 | Level: Level 2 | 3 | L42C
762673 | 2AC2 | Level: Level 2 | 3 | L42C
762838 | 2AC2 | Level: Level 2 | 3 | L42C
763143 | 2C07 | Level: Level 2 | 2 | L42C
817488 | 1DC8 | Level: Level 1 | 4 | L41B

# IfcFlowTerminal: B3D - 610x610mm (6)
In: 1B19
Type - ElementType: B3D - 610x610mm; Classification:  (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Glass - White, High Luminance, Metal - Chrome
Constraints - Default Elevation: 1.2 m; Host: Linked Revit Model : Clinic_A.rvt; Elevation: 2.68 m
Electrical - Loads - Apparent Load: 430.556; Panel: L41B; Circuit Number: 1
Dimensions - Light Source Symbol Size: 0.05 m
Materials and Finishes - Diffuser Material: Glass - White, High Luminance; Grid Material: Metal - Paint Finish - Dark Gray, Matte; Light Box Material: Metal - Chrome
Identity Data - Manufacturer: N/A; OmniClass Number: 23.80.70.11.14.11; Type Mark: B3D; OmniClass Title: Downlights; Description: SAME AS B3 EXCEPT WITH DIMMING BALLAST
Electrical - Wattage Comments: 32; Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67; Lamp: U-SHAPED, CRI=75
Photometrics - Color Filter: 16777215; Light Loss Factor: 0; Dimming Lamp Color Temperature Shift: 0; Initial Intensity: 0; Light Source Definition (family): Point+HemiSpherical; Initial Color: 0; Lumens: 3150
Other - AssetAccountingType: FIXED; NumberOfPoles: 0; WarrantyGuarantorLabor: N/A; SensibleLoadToRadiant: 0; WarrantyDurationLabor: N/A; AccessibilityPerformance: N/A; WarrantyDescription: N/A; ProductionYear: N/A; Grade: N/A; NominalWidth: 0; ConductorFunction: L1; MaximumSpaceSensibleLoad: 0; NumberOfSources: 0; Shape: N/A; ReplacementCost: N/A; IP_Code: 0; HasProtectiveEarth: TRUE; ModelReference: N/A; NominalFrequencyRange: 0; RatedCurrent: 0; RatedVoltage: 0; ModelLabel: N/A; Material: N/A; WarrantyGuarantorParts: N/A; SustainabilityPerformance: N/A; TotalWattage: 0; Features: N/A; NominalLength: 0; MaintenanceFactor: 0; ExpectedLife: N/A; MaximumPlenumSensibleLoad: 0; PowerFactor: 0; WarrantyDurationParts: N/A; Constituents: N/A; NominalHeight: 0; CodePerformance: N/A; Size: 0; TagNumber: N/A; WarrantyStartDate: N/A; SerialNumber: N/A; BarCode: N/A; Reference: REF TYPE MARK; FixtureHeight: 0; Schedule Level: Level: Level 1; AssetIdentifier: N/A; InstallationDate: N/A; BackupSupplySystem: NO
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-40 VA
Name (M_Troffer Light - Parabolic Square:B3D - 610x610mm:B3D - 610x610mm:...)
743764
743772
743800
743859
827061
827067

# IfcFlowTerminal: B3DB - 610x610mm (2)
In: 1B19
Type - ElementType: B3DB - 610x610mm; Classification:  (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Glass - White, High Luminance, Metal - Chrome
Dimensions - Light Source Symbol Size: 0.05 m
Electrical - Loads - Apparent Load: 430.556; Circuit Number: 1; Panel: L41B
Constraints - Default Elevation: 1.2 m; Elevation: 2.68 m; Host: Linked Revit Model : Clinic_A.rvt
Electrical - Ballast Voltage: 1291.67; Load Classification: Lighting - Dwelling Unit; Lamp: U-SHAPED, CRI=75; Ballast Number of Poles: 1; Wattage Comments: 32
Materials and Finishes - Grid Material: Metal - Paint Finish - Dark Gray, Matte; Diffuser Material: Glass - White, High Luminance; Light Box Material: Metal - Chrome
Identity Data - Type Mark: B3DB; Manufacturer: N/A; Description: SAME AS B3D EXCEPT WITH EMERGENCY BATTERY PACK; OmniClass Title: Downlights; OmniClass Number: 23.80.70.11.14.11
Other - ReplacementCost: N/A; NominalLength: 0; MaintenanceFactor: 0; SustainabilityPerformance: N/A; Features: N/A; MaximumSpaceSensibleLoad: 0; MaximumPlenumSensibleLoad: 0; RatedVoltage: 0; AssetAccountingType: FIXED; HasProtectiveEarth: TRUE; NominalWidth: 0; WarrantyDurationLabor: N/A; CodePerformance: N/A; NumberOfSources: 0; IP_Code: 0; AccessibilityPerformance: N/A; ConductorFunction: L1; RatedCurrent: 0; WarrantyGuarantorLabor: N/A; Constituents: N/A; WarrantyDescription: N/A; Grade: N/A; Material: N/A; ModelReference: N/A; Shape: N/A; NominalHeight: 0; ProductionYear: N/A; ExpectedLife: N/A; ModelLabel: N/A; WarrantyDurationParts: N/A; TotalWattage: 0; NumberOfPoles: 0; NominalFrequencyRange: 0; Size: 0; SensibleLoadToRadiant: 0; WarrantyGuarantorParts: N/A; PowerFactor: 0; Schedule Level: Level: Level 1; InstallationDate: N/A; Reference: REF TYPE MARK; BarCode: N/A; FixtureHeight: 0; SerialNumber: N/A; WarrantyStartDate: N/A; BackupSupplySystem: YES; TagNumber: N/A; AssetIdentifier: N/A
Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: 0; Initial Intensity: 0; Light Loss Factor: 0; Light Source Definition (family): Point+HemiSpherical; Initial Color: 0; Lumens: 3150
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-40 VA
Name (M_Troffer Light - Parabolic Square:B3DB - 610x610mm:B3DB - 610x610mm:...)
743782
743810

# IfcFlowTerminal: C1 - 0610x1219mm (22)
Type - ElementType: C1 - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Other - InstallationDate: N/A; TagNumber: N/A; Reference: REF TYPE MARK; WarrantyStartDate: N/A; BackupSupplySystem: NO; FixtureHeight: 0; AssetIdentifier: N/A; SerialNumber: N/A; BarCode: N/A; WarrantyDescription: N/A; NominalLength: 0; PowerFactor: 0; MaintenanceFactor: 0; MaximumPlenumSensibleLoad: 0; WarrantyDurationLabor: N/A; Grade: N/A; ExpectedLife: N/A; NominalWidth: 0; TotalWattage: 0; MaximumSpaceSensibleLoad: 0; IP_Code: 0; ModelReference: N/A; RatedCurrent: 0; WarrantyDurationParts: N/A; ConductorFunction: L1; RatedVoltage: 0; Material: N/A; HasProtectiveEarth: TRUE; CodePerformance: N/A; Features: N/A; ModelLabel: N/A; NumberOfPoles: 0; AccessibilityPerformance: N/A; Constituents: N/A; ReplacementCost: N/A; NominalHeight: 0; WarrantyGuarantorParts: N/A; AssetAccountingType: FIXED; WarrantyGuarantorLabor: N/A; Shape: N/A; NumberOfSources: 0; NominalFrequencyRange: 0; SensibleLoadToRadiant: 0; SustainabilityPerformance: N/A; ProductionYear: N/A; Size: 0
Phasing - Phase Created: New Construction
Constraints - Elevation: 2.68 m; Default Elevation: 1.2 m
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Materials and Finishes - Grid Material: Metal - Paint Finish - Dark Gray, Matte; Diffuser Material: Glass - White, High Luminance; Light Box Material: Metal - Chrome
Dimensions - Light Source Symbol Size: 0.05 m
Electrical - Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Ballast Voltage: 1291.67; Wattage Comments: 32; Lamp: T8, 1219mm, RAPID START, CRI=75
Photometrics - Lumens: 2900; Light Loss Factor: 0; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Light Source Definition (family): Point+HemiSpherical; Initial Intensity: 0; Color Filter: 16777215
Electrical - Loads - Apparent Load: 861.113
Identity Data - Manufacturer: N/A; OmniClass Title: Downlights; Assembly Code: D5020210; OmniClass Number: 23.80.70.11.14.11; Description: 610mm X 1219MM (NOMIMAL) RECESSED TROFFER. A-12 PRISMATIC LENS, BAKED WHITE ENAMEL FINISH.; Type Mark: C1; Assembly Description: Lighting - Fluorescent
Name (M_Troffer Light - Parabolic Rectangular:C1 - 0610x1219mm:C1 - 0610x1219mm:...) | In | Panel | Circuit Number | Schedule Level | Host
739480 | 1C15 | N21C1 | 22 | Level: Level 1 | <not associated>
739488 | 1C15 | N21C1 | 22 | Level: Level 1 | <not associated>
739496 | 1C15 | N21C1 | 22 | Level: Level 1 | <not associated>
740360 | 1E25 | L41B | 7 | Level: Level 1 | <not associated>
740368 | 1E25 | L41B | 7 | Level: Level 1 | <not associated>
741052 | 1B03 | L41B | 1 | Level: Level 1 | <not associated>
741118 | 1C04 | L41C | 9 | Level: Level 1 | <not associated>
741128 | 1C04 | L41C | 9 | Level: Level 1 | <not associated>
757603 | 2C11 | L42C | 1 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
765582 | 2C03 | L42C | 2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
765675 | 2C03 | L42C | 2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
765736 | 2C01 | L42C | 2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
765785 | 2C01 | L42C | 2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
765853 | 2C03 | L42C | 2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
765913 | 2C03 | L42C | 2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
766651 | 2B4 | L42B | 1 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
766726 | 2B4 | L42B | 1 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
769225 | 2D10 | L42B | 6 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
769336 | 2D10 | L42B | 6 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
772786 | 2B17 | L42B | 3 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
772866 | 2B15 | L42B | 3 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
772961 | 2B15 | L42B | 3 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt

# IfcFlowTerminal: C18 - 0610x1219mm (37)
Type - ElementType: C18 - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Other - AssetIdentifier: N/A; BarCode: N/A; FixtureHeight: 0; BackupSupplySystem: NO; TagNumber: N/A; Schedule Level: Level: Level 1; Reference: REF TYPE MARK; SerialNumber: N/A; WarrantyStartDate: N/A; InstallationDate: N/A; ModelReference: N/A; NominalHeight: 0; ConductorFunction: L1; ExpectedLife: N/A; Size: 0; NominalWidth: 0; AssetAccountingType: FIXED; NumberOfPoles: 0; Features: N/A; NominalLength: 0; Constituents: N/A; RatedVoltage: 0; Grade: N/A; NominalFrequencyRange: 0; TotalWattage: 0; WarrantyDurationLabor: N/A; MaximumPlenumSensibleLoad: 0; CodePerformance: N/A; RatedCurrent: 0; NumberOfSources: 0; Shape: N/A; ReplacementCost: N/A; HasProtectiveEarth: TRUE; MaintenanceFactor: 0; IP_Code: 0; SustainabilityPerformance: N/A; WarrantyDurationParts: N/A; WarrantyGuarantorParts: N/A; PowerFactor: 0; WarrantyDescription: N/A; SensibleLoadToRadiant: 0; WarrantyGuarantorLabor: N/A; Material: N/A; MaximumSpaceSensibleLoad: 0; ProductionYear: N/A; AccessibilityPerformance: N/A; ModelLabel: N/A
Phasing - Phase Created: New Construction
Constraints - Host: <not associated>; Elevation: 2.68 m; Default Elevation: 1.2 m
Electrical - Wattage Comments: 32; Lamp: T8, 1219mm, RAPID START, CRI=85 MINI; Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67
Dimensions - Light Source Symbol Size: 0.05 m
Electrical - Loads - Apparent Load: 861.113
Materials and Finishes - Light Box Material: Metal - Chrome; Grid Material: Metal - Paint Finish - Dark Gray, Matte; Diffuser Material: Glass - White, High Luminance
Photometrics - Color Filter: 16777215; Initial Intensity: 0; Lumens: 2900; Light Loss Factor: 0; Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Dimming Lamp Color Temperature Shift: 0
Identity Data - OmniClass Title: Downlights; OmniClass Number: 23.80.70.11.14.11; Assembly Description: Lighting - Fluorescent; Assembly Code: D5020210; Type Mark: C18; Description: SAME AS C1 EXCEPT 85 COLOR RENDERING LAMPS; Manufacturer: N/A
Name (M_Troffer Light - Parabolic Rectangular:C18 - 0610x1219mm:C18 - 0610x1219mm:...) | In | Circuit Number | Panel
738399 | 1D38 | 4 | L41B
738555 | 1D36 | 4 | L41B
738567 | 1D36 | 4 | L41B
738575 | 1D34 | 4 | L41B
738583 | 1D34 | 4 | L41B
738615 | 1D32 | 4 | L41B
738625 | 1D32 | 4 | L41B
738635 | 1D28 | 4 | L41B
738643 | 1D28 | 4 | L41B
739220 | 1D10 | 3 | L41C
739228 | 1D10 | 3 | L41C
739236 | 1D08 | 3 | L41C
739244 | 1D08 | 3 | L41C
739254 | 1D05 | 24 | N21C1
739262 | 1D06 | 24 | N21C1
739270 | 1D06 | 24 | N21C1
739280 | 1D07 | 3 | L41C
739294 | 1D07 | 3 | L41C
739304 | 1D09 | 3 | L41C
739312 | 1D09 | 3 | L41C
739332 | 1D11 | 3 | L41C
739342 | 1D11 | 3 | L41C
739352 | 1D13 | 3 | L41C
739360 | 1D13 | 3 | L41C
739506 | 1C18 | 4 | L41C
739514 | 1C18 | 4 | L41C
739522 | 1C18 | 4 | L41C
739542 | 1C18 | 4 | L41C
739550 | 1C18 | 4 | L41C
739558 | 1C18 | 4 | L41C
739566 | 1C18 | 4 | L41C
739574 | 1C18 | 4 | L41C
740868 | 1D38 | 4 | L41B
740874 | 1D38 | 4 | L41B
741172 | 1D02 | 3 | L41C
741278 | 1D02 | 3 | L41C
741352 | 1D05 | 24 | N21C1

# IfcFlowTerminal: C18B - 0610x1219mm (4)
Type - ElementType: C18B - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Other - BarCode: N/A; TagNumber: N/A; Reference: REF TYPE MARK; Schedule Level: Level: Level 1; FixtureHeight: 0; AssetIdentifier: N/A; SerialNumber: N/A; BackupSupplySystem: NO; InstallationDate: N/A; WarrantyStartDate: N/A; AccessibilityPerformance: N/A; MaximumPlenumSensibleLoad: 0; MaintenanceFactor: 0; ReplacementCost: N/A; RatedVoltage: 0; Shape: N/A; Constituents: N/A; SensibleLoadToRadiant: 0; Grade: N/A; CodePerformance: N/A; ConductorFunction: L1; TotalWattage: 0; ExpectedLife: N/A; MaximumSpaceSensibleLoad: 0; Size: 0; NumberOfPoles: 0; Features: N/A; ProductionYear: N/A; PowerFactor: 0; WarrantyDescription: N/A; Material: N/A; WarrantyDurationLabor: N/A; WarrantyGuarantorLabor: N/A; NominalWidth: 0; ModelReference: N/A; NominalHeight: 0; NumberOfSources: 0; ModelLabel: N/A; RatedCurrent: 0; WarrantyDurationParts: N/A; HasProtectiveEarth: TRUE; AssetAccountingType: FIXED; SustainabilityPerformance: N/A; NominalFrequencyRange: 0; NominalLength: 0; WarrantyGuarantorParts: N/A; IP_Code: 0
Phasing - Phase Created: New Construction
Constraints - Elevation: 2.68 m; Host: <not associated>; Default Elevation: 1.2 m
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Materials and Finishes - Light Box Material: Metal - Chrome; Diffuser Material: Glass - White, High Luminance; Grid Material: Metal - Paint Finish - Dark Gray, Matte
Electrical - Loads - Apparent Load: 861.113
Dimensions - Light Source Symbol Size: 0.05 m
Electrical - Lamp: T8, 1219mm, RAPID START, CRI=85 MINI; Wattage Comments: 32; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67; Ballast Number of Poles: 1
Photometrics - Lumens: 2900; Initial Intensity: 0; Initial Color: 0; Light Loss Factor: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215; Light Source Definition (family): Point+HemiSpherical
Identity Data - Manufacturer: N/A; Type Mark: C18B; Assembly Description: Lighting - Fluorescent; Description: SAME AS C18 EXCEPT 85 COLOR RENDERING LAMPS; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights; Assembly Code: D5020210
Name (M_Troffer Light - Parabolic Rectangular:C18B - 0610x1219mm:C18B - 0610x1219mm:...) | In | Circuit Number | Panel
738409 | 1D38 | 4 | L41B
739530 | 1C18 | 4 | L41C
739629 | 1C18 | 4 | L41C
741344 | 1D05 | 24 | N21C1

# IfcFlowTerminal: C1B - 0610x1219mm (2)
Type - ElementType: C1B - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Constraints - Elevation: 2.68 m; Default Elevation: 1.2 m
Electrical - Lighting - Calculate Coefficient of Utilization: no
Other - TagNumber: N/A; InstallationDate: N/A; SerialNumber: N/A; Reference: REF TYPE MARK; BackupSupplySystem: YES; AssetIdentifier: N/A; FixtureHeight: 0; WarrantyStartDate: N/A; BarCode: N/A; SustainabilityPerformance: N/A; Constituents: N/A; WarrantyGuarantorLabor: N/A; MaximumSpaceSensibleLoad: 0; MaximumPlenumSensibleLoad: 0; NumberOfPoles: 0; SensibleLoadToRadiant: 0; TotalWattage: 0; NominalHeight: 0; WarrantyDurationParts: N/A; ConductorFunction: L1; RatedVoltage: 0; ProductionYear: N/A; NominalFrequencyRange: 0; ModelReference: N/A; IP_Code: 0; WarrantyDescription: N/A; ExpectedLife: N/A; Features: N/A; ReplacementCost: N/A; WarrantyGuarantorParts: N/A; NominalWidth: 0; CodePerformance: N/A; RatedCurrent: 0; MaintenanceFactor: 0; Grade: N/A; Shape: N/A; NumberOfSources: 0; Material: N/A; HasProtectiveEarth: TRUE; AssetAccountingType: FIXED; ModelLabel: N/A; WarrantyDurationLabor: N/A; AccessibilityPerformance: N/A; Size: 0; PowerFactor: 0; NominalLength: 0
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Dimensions - Light Source Symbol Size: 0.05 m
Electrical - Wattage Comments: 32; Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Ballast Voltage: 1291.67; Lamp: T8, 1219mm, RAPID START, CRI=75
Identity Data - OmniClass Number: 23.80.70.11.14.11; Assembly Code: D5020210; Type Mark: C1B; Assembly Description: Lighting - Fluorescent; Manufacturer: N/A; Description: SAME AS C1 EXCEPT WITH EMERGENCY BATTERY PACK; OmniClass Title: Downlights
Electrical - Loads - Apparent Load: 861.113
Materials and Finishes - Grid Material: Metal - Paint Finish - Dark Gray, Matte; Light Box Material: Metal - Chrome; Diffuser Material: Glass - White, High Luminance
Photometrics - Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Initial Intensity: 0; Color Filter: 16777215; Lumens: 2900; Dimming Lamp Color Temperature Shift: 0; Light Loss Factor: 0
Name (M_Troffer Light - Parabolic Rectangular:C1B - 0610x1219mm:C1B - 0610x1219mm:...) | In | Host | Schedule Level | Panel | Circuit Number
741060 | 1B03 | <not associated> | Level: Level 1 | L41B | 1
769304 | 2D10 | Linked Revit Model : Clinic_A.rvt | Level: Level 2 | L42B | 6

# IfcFlowTerminal: C1D - 0610x1219mm (3)
Type - ElementType: C1D - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Other - BackupSupplySystem: NO; BarCode: N/A; Reference: REF TYPE MARK; InstallationDate: N/A; SerialNumber: N/A; Schedule Level: Level: Level 1; FixtureHeight: 0; AssetIdentifier: N/A; WarrantyStartDate: N/A; TagNumber: N/A; CodePerformance: N/A; SensibleLoadToRadiant: 0; ModelLabel: N/A; WarrantyGuarantorParts: N/A; RatedCurrent: 0; MaximumSpaceSensibleLoad: 0; HasProtectiveEarth: TRUE; NumberOfPoles: 0; Grade: N/A; RatedVoltage: 0; ConductorFunction: L1; NumberOfSources: 0; AccessibilityPerformance: N/A; AssetAccountingType: FIXED; ModelReference: N/A; NominalLength: 0; ReplacementCost: N/A; ExpectedLife: N/A; PowerFactor: 0; MaintenanceFactor: 0; Material: N/A; NominalHeight: 0; TotalWattage: 0; WarrantyDurationLabor: N/A; Shape: N/A; WarrantyGuarantorLabor: N/A; IP_Code: 0; NominalFrequencyRange: 0; MaximumPlenumSensibleLoad: 0; WarrantyDescription: N/A; ProductionYear: N/A; WarrantyDurationParts: N/A; Features: N/A; SustainabilityPerformance: N/A; NominalWidth: 0; Constituents: N/A; Size: 0
Electrical - Lighting - Calculate Coefficient of Utilization: no
Constraints - Elevation: 2.68 m; Host: <not associated>; Default Elevation: 1.2 m
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Electrical - Loads - Apparent Load: 861.113
Dimensions - Light Source Symbol Size: 0.05 m
Materials and Finishes - Light Box Material: Metal - Chrome; Diffuser Material: Glass - White, High Luminance; Grid Material: Metal - Paint Finish - Dark Gray, Matte
Electrical - Ballast Voltage: 1291.67; Wattage Comments: 32; Load Classification: Lighting - Dwelling Unit; Lamp: T8, 1219mm, RAPID START, CRI=75; Ballast Number of Poles: 1
Identity Data - Assembly Description: Lighting - Fluorescent; Description: SAME AS C1 EXCEPT WITH DIMMING BALLAST; OmniClass Number: 23.80.70.11.14.11; Type Mark: C1D; Manufacturer: N/A; OmniClass Title: Downlights; Assembly Code: D5020210
Photometrics - Light Source Definition (family): Point+HemiSpherical; Initial Color: 0; Color Filter: 16777215; Initial Intensity: 0; Lumens: 2900; Dimming Lamp Color Temperature Shift: 0; Light Loss Factor: 0
Name (M_Troffer Light - Parabolic Rectangular:C1D - 0610x1219mm:C1D - 0610x1219mm:...) | In | Circuit Number | Panel
739699 | 1C05 | 9 | L41C
739707 | 1C05 | 9 | L41C
741042 | 1B15 | 1 | L41B

# IfcFlowTerminal: D18 - 0610x1219mm (6)
In: 2C17
Type - ElementType: D18 - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Dimensions - Light Source Symbol Size: 0.05 m
Constraints - Default Elevation: 1.2 m; Elevation: 2.68 m; Host: Linked Revit Model : Clinic_A.rvt
Electrical - Lamp: T8 or TH10, 1219mm, RAPID START, CRI=90 T8 or TH10, 1219mm, RAPID START, CRI=90 T8 or TH10, 1219mm, RAPID START, CRI=90 T8 or TH10, 1219mm, RAPID START, CRI=90 T8 or TH10, 1219mm, RAPID START, CRI=90; Wattage Comments: 32 or 30; Ballast Number of Poles: 1; Ballast Voltage: 1291.67; Load Classification: Lighting - Dwelling Unit
Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: 0; Light Loss Factor: 0; Light Source Definition (family): Point+HemiSpherical; Initial Intensity: 0; Lumens: 1800; Initial Color: 0
Electrical - Loads - Apparent Load: 861.113; Circuit Number: 1; Panel: L42C
Materials and Finishes - Grid Material: Metal - Paint Finish - Dark Gray, Matte; Diffuser Material: Glass - White, High Luminance; Light Box Material: Metal - Chrome
Identity Data - Type Mark: D18; OmniClass Number: 23.80.70.11.14.11; Manufacturer: N/A; Assembly Code: D5020210; Description: 610mm X 1219MM (NOMIMAL) RECESSED TROFFER. A-12 PRISMATIC LENS, BAKED WHITE ENAMEL FINISH.; OmniClass Title: Downlights; Assembly Description: Lighting - Fluorescent
Other - RatedVoltage: 0; NumberOfSources: 0; IP_Code: 0; TotalWattage: 0; ModelReference: N/A; SensibleLoadToRadiant: 0; ProductionYear: N/A; CodePerformance: N/A; AccessibilityPerformance: N/A; MaximumPlenumSensibleLoad: 0; ReplacementCost: N/A; HasProtectiveEarth: TRUE; NominalWidth: 0; ConductorFunction: L1; SustainabilityPerformance: N/A; Grade: N/A; ExpectedLife: N/A; Size: 0; PowerFactor: 0; MaintenanceFactor: 0; NominalFrequencyRange: 0; WarrantyDescription: N/A; WarrantyDurationParts: N/A; Constituents: N/A; NumberOfPoles: 0; AssetAccountingType: FIXED; RatedCurrent: 0; Shape: N/A; ModelLabel: N/A; WarrantyDurationLabor: N/A; WarrantyGuarantorLabor: N/A; Material: N/A; Features: N/A; MaximumSpaceSensibleLoad: 0; NominalLength: 0; WarrantyGuarantorParts: N/A; NominalHeight: 0; Schedule Level: Level: Level 2; WarrantyStartDate: N/A; BarCode: N/A; BackupSupplySystem: NO; FixtureHeight: 0; Reference: REF TYPE MARK; TagNumber: N/A; SerialNumber: N/A; InstallationDate: N/A; AssetIdentifier: N/A
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Name (M_Troffer Light - Parabolic Rectangular:D18 - 0610x1219mm:D18 - 0610x1219mm:...)
764213
764308
764374
764448
764496
764616

# IfcFlowTerminal: E1 - 1219mm (2)
Type - ElementType: E1 - 1219mm; Classification:  (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Materials and Finishes - Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance
Dimensions - Light Source Symbol Size: 0.05 m; Light Casing Length: 1.219 m; Drop From Ceiling: 0.1 m
Photometrics - Color Filter: 16777215; Initial Intensity: 0; Lumens: 2900; Light Source Definition (family): Point+HemiSpherical; Dimming Lamp Color Temperature Shift: 0; Initial Color: 0; Light Loss Factor: 0
Electrical - Loads - Apparent Load: 1614.59
Constraints - Default Elevation: 1.2 m
Electrical - Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Lamp: T8, 1219mm, RAPID START, CRI=75; Ballast Voltage: 1291.67; Wattage Comments: 32
Identity Data - Type Mark: E1; OmniClass Number: 23.80.70.11.11; Manufacturer: N/A; OmniClass Title: General Luminaries, Non Directional; Description: 1219 SURFACE MOUNTED FLOURESCENT WITH UP/DOWN LIGHT DISTRIBUTION, ALUMINUM EXTRUSION SHELL ACRYLIC PRISMATIC LENS ON BOTTOM, CLEAR ACRYLIC LENS ON TOP. NO SWITCH OR RECEPTACLE. PROVIDE EMERGENCY PACK.
Other - RatedCurrent: 0; WarrantyGuarantorLabor: N/A; ModelReference: N/A; NominalWidth: 0; SustainabilityPerformance: N/A; AccessibilityPerformance: N/A; IP_Code: 0; WarrantyDescription: N/A; CodePerformance: N/A; Grade: N/A; PowerFactor: 0; ModelLabel: N/A; HasProtectiveEarth: TRUE; Size: 0; MaximumPlenumSensibleLoad: 0; WarrantyGuarantorParts: N/A; WarrantyDurationLabor: N/A; NominalHeight: 0; RatedVoltage: 0; Shape: N/A; MaximumSpaceSensibleLoad: 0; ExpectedLife: N/A; Material: N/A; Features: N/A; NumberOfPoles: 0; ConductorFunction: L1; TotalWattage: 0; WarrantyDurationParts: N/A; NominalLength: 0; NominalFrequencyRange: 0; NumberOfSources: 0; MaintenanceFactor: 0; ProductionYear: N/A; SensibleLoadToRadiant: 0; Constituents: N/A; ReplacementCost: N/A; AssetAccountingType: FIXED; AssetIdentifier: N/A; FixtureHeight: 0; SerialNumber: N/A; Reference: REF TYPE MARK; InstallationDate: N/A; BackupSupplySystem: NO; WarrantyStartDate: N/A; TagNumber: N/A; BarCode: N/A
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-150 VA
Name (M_Surface Mounted Light:E1 - 1219mm:E1 - 1219mm:...) | In | Panel | Circuit Number | Schedule Level | Host | Elevation (m)
745139 | 1ES2 | L41B | 2 | Level: Level 1 | Linked Revit Model : Clinic_S.rvt | 4.468
776789 | 2BS2 | L42B | 4 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68

# IfcFlowTerminal: E2 - 610mm (3)
Type - ElementType: E2 - 610mm; Classification:  (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Electrical - Loads - Apparent Load: 1614.59
Constraints - Default Elevation: 1.2 m; Elevation: 2.68 m; Host: Linked Revit Model : Clinic_A.rvt
Dimensions - Drop From Ceiling: 0.1 m; Light Source Symbol Size: 0.05 m; Light Casing Length: 0.61 m
Photometrics - Color Filter: 16777215; Light Loss Factor: 0; Lumens: 1375; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Initial Intensity: 0; Light Source Definition (family): Point+HemiSpherical
Materials and Finishes - Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy
Electrical - Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67; Ballast Number of Poles: 1; Wattage Comments: 17; Lamp: T8, 1219mm, RAPID START, CRI=75
Identity Data - OmniClass Title: General Luminaries, Non Directional; Description: SAME AS E1 EXCEPT 610mm and DOWN LIGHT ONLY. INSTALL ABOVE MIRROR.; Manufacturer: N/A; OmniClass Number: 23.80.70.11.11; Type Mark: E2
Other - RatedVoltage: 0; NominalHeight: 0; WarrantyGuarantorParts: N/A; HasProtectiveEarth: TRUE; NominalFrequencyRange: 0; WarrantyDurationLabor: N/A; ConductorFunction: L1; NominalWidth: 0; Shape: N/A; ModelReference: N/A; WarrantyGuarantorLabor: N/A; IP_Code: 0; ReplacementCost: N/A; Grade: N/A; TotalWattage: 0; SensibleLoadToRadiant: 0; ProductionYear: N/A; ExpectedLife: N/A; AssetAccountingType: FIXED; NominalLength: 0; MaximumSpaceSensibleLoad: 0; NumberOfPoles: 0; ModelLabel: N/A; RatedCurrent: 0; Material: N/A; CodePerformance: N/A; MaintenanceFactor: 0; WarrantyDurationParts: N/A; Constituents: N/A; Size: 0; Features: N/A; WarrantyDescription: N/A; PowerFactor: 0; AccessibilityPerformance: N/A; SustainabilityPerformance: N/A; MaximumPlenumSensibleLoad: 0; NumberOfSources: 0; InstallationDate: N/A; SerialNumber: N/A; WarrantyStartDate: N/A; BackupSupplySystem: NO; TagNumber: N/A; AssetIdentifier: N/A; Reference: REF TYPE MARK; BarCode: N/A; FixtureHeight: 0
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-150 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Name (M_Surface Mounted Light:E2 - 610mm:E2 - 610mm:...) | In | Schedule Level | Circuit Number | Panel
779597 | 2C23 | Level: Level 2 | 2 | L42C
779644 | 2C03 | Level: Level 2 | 2 | L42C
809705 | 1D18 | Level: Level 1 | 5 | L41C

# IfcFlowTerminal: F1 - 0610x1219mm, M_Troffer Light - Parabolic Rectangular:F1 - 0610x1219mm:F1 - 0610x1219mm:738539
In: 1E08
Type - ElementType: F1 - 0610x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Constraints - Host: <not associated>; Elevation: 2.68 m; Default Elevation: 1.2 m
Other - FixtureHeight: 0; AssetIdentifier: N/A; SerialNumber: N/A; Schedule Level: Level: Level 1; BarCode: N/A; BackupSupplySystem: NO; WarrantyStartDate: N/A; TagNumber: N/A; InstallationDate: N/A; Reference: REF TYPE MARK; Material: N/A; WarrantyDurationLabor: N/A; MaximumPlenumSensibleLoad: 0; ModelReference: N/A; WarrantyDurationParts: N/A; WarrantyGuarantorParts: N/A; AccessibilityPerformance: N/A; Size: 0; NumberOfSources: 0; MaximumSpaceSensibleLoad: 0; IP_Code: 0; Grade: N/A; WarrantyDescription: N/A; AssetAccountingType: FIXED; RatedVoltage: 0; ModelLabel: N/A; TotalWattage: 0; ProductionYear: N/A; SensibleLoadToRadiant: 0; NominalFrequencyRange: 0; RatedCurrent: 0; Constituents: N/A; ExpectedLife: N/A; Features: N/A; CodePerformance: N/A; SustainabilityPerformance: N/A; HasProtectiveEarth: TRUE; PowerFactor: 0; NominalLength: 0; MaintenanceFactor: 0; NumberOfPoles: 0; ConductorFunction: L1; NominalHeight: 0; WarrantyGuarantorLabor: N/A; Shape: N/A; ReplacementCost: N/A; NominalWidth: 0
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Loads - Panel: L41B; Circuit Number: 3; Apparent Load: 861.113
Phasing - Phase Created: New Construction
Materials and Finishes - Light Box Material: Metal - Chrome; Diffuser Material: Glass - White, High Luminance; Grid Material: Metal - Paint Finish - Dark Gray, Matte
Electrical - Lamp: T8, 1219mm, RAPID START, CRI=75; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67; Wattage Comments: 32; Ballast Number of Poles: 1
Identity Data - Assembly Description: Lighting - Fluorescent; OmniClass Number: 23.80.70.11.14.11; Manufacturer: N/A; Assembly Code: D5020210; Type Mark: F1; Description: 610mm X 1219MM (NOMIMAL) RECESSED TROFFER. A-12 PRISMATIC LENS, BAKED WHITE ENAMEL FINISH.; OmniClass Title: Downlights
Photometrics - Dimming Lamp Color Temperature Shift: 0; Initial Intensity: 0; Color Filter: 16777215; Light Loss Factor: 0; Lumens: 2900; Light Source Definition (family): Point+HemiSpherical; Initial Color: 0
Dimensions - Light Source Symbol Size: 0.05 m

# IfcFlowTerminal: GFCI (3)
Type - ElementType: GFCI; PredefinedType: POWEROUTLET; Classification:  (UniFormat)
Constraints - Default Elevation: 1.2 m; Offset: 0 m; Host: Linked Revit Model : Clinic_A.rvt
Electrical - Load Classification: Receptacle; Switch Voltage: 1291.67; Load: 1937.5
Identity Data - OmniClass Number: 23.80.50.11.17; OmniClass Title: Ground Fault Receptacles; Manufacturer: N/A; Label: GFCI
Other - NumberOfPoles: 0; ReplacementCost: N/A; NominalFrequencyRange: 0; WarrantyGuarantorParts: N/A; Size: 0; ModelReference: N/A; NominalLength: 0; WarrantyDescription: N/A; NominalWidth: 0; WarrantyDurationParts: N/A; ExpectedLife: N/A; RatedVoltage: 0; CodePerformance: N/A; IP_Code: 0; AssetAccountingType: FIXED; PowerFactor: 0; IsPluggableOutlet: TRUE; WarrantyDurationLabor: N/A; HasProtectiveEarth: TRUE; ConductorFunction: L1; NominalHeight: 0; AccessibilityPerformance: N/A; Features: N/A; Grade: N/A; Constituents: N/A; ProductionYear: N/A; WarrantyGuarantorLabor: N/A; Shape: N/A; ModelLabel: N/A; Material: N/A; SustainabilityPerformance: N/A; RatedCurrent: 0; BarCode: N/A; WarrantyStartDate: N/A; TagNumber: N/A; AssetIdentifier: N/A; SerialNumber: N/A; InstallationDate: N/A
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-180 VA
Name (M_Duplex Receptacle:GFCI:GFCI:...) | In | Schedule Level | Elevation (m) | Panel | Circuit Number | Mark
868750 | 1C03 | Level: Level 1 | 1 | N21C | 14 | 69
940963 | 2B22 | Level: Level 2 | 0.5 | N22B1 | 24 | 542
946499 | 2B6 | Level: Level 2 | 0.5 | N22B1 | 14 | 590

# IfcFlowTerminal: LV - 203mm Diameter (16)
Type - ElementType: LV - 203mm Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Constraints - Default Elevation: 1.2 m
Electrical - Loads - Apparent Load: 1076.39; Panel: L41C
Electrical - Lamp: MR16; Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67; Wattage Comments: 50
Identity Data - Description: RECESSED HALOGEN DOWNLIGHT; Assembly Code: D5020220; OmniClass Number: 23.80.70.11.14.11; Assembly Description: Lighting - Incandescent; Type Mark: LV; OmniClass Title: Downlights; Manufacturer: N/A
Other - NominalLength: 0; AccessibilityPerformance: N/A; ReplacementCost: N/A; Recessing Radius: 0.1 m; ConductorFunction: L1; WarrantyDurationLabor: N/A; Size: 0; Constituents: N/A; PowerFactor: 0; SustainabilityPerformance: N/A; Material: N/A; NominalWidth: 0; ExpectedLife: N/A; Features: N/A; Shape: N/A; NumberOfPoles: 0; RatedVoltage: 0; CodePerformance: N/A; SensibleLoadToRadiant: 0; WarrantyGuarantorParts: N/A; WarrantyDescription: N/A; Grade: N/A; WarrantyGuarantorLabor: N/A; TotalWattage: 0; NominalFrequencyRange: 0; ModelReference: N/A; IP_Code: 0; RatedCurrent: 0; ProductionYear: N/A; WarrantyDurationParts: N/A; ModelLabel: N/A; MaintenanceFactor: 0; NumberOfSources: 0; NominalHeight: 0; AssetAccountingType: FIXED; MaximumSpaceSensibleLoad: 0; MaximumPlenumSensibleLoad: 0; Recessing Inner Radius: 0.0873 m; HasProtectiveEarth: TRUE; BarCode: N/A; AssetIdentifier: N/A; SerialNumber: N/A; BackupSupplySystem: NO; Reference: REF TYPE MARK; InstallationDate: N/A; Schedule Level: Level: Level 1; TagNumber: N/A; FixtureHeight: 0; WarrantyStartDate: N/A
Photometrics - Light Loss Factor: 0; Lumens: 0; Dimming Lamp Color Temperature Shift: 0; Initial Intensity: 0; Initial Color: 0; Color Filter: 16777215; Light Source Definition (family): Point+HemiSpherical
Dimensions - Light Source Symbol Size: 0.05 m; Recessing Height: 0.2 m; Recessing Diameter: 0.2 m
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Name (M_Downlight - Recessed Can:LV - 203mm Diameter:LV - 203mm Diameter:...) | In | Circuit Number | Host | Elevation (m)
751529 | 1DC1 | 8 | Linked Revit Model : Clinic_A.rvt | 2.5
751607 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 2.5
751662 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 2.8
751761 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 2.5
751813 | 1AC1 | 7 | <not associated> | 2.5
751885 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 2.8
751943 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 3.8
752026 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 3.8
752081 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 3.8
752303 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 2.5
752368 | 1AC1 | 7 | <not associated> | 2.5
752424 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 2.5
753990 | 1AC1 | 7 | Linked Revit Model : Clinic_A.rvt | 2.5
927191 | 1DC1 | 8 | Linked Revit Model : Clinic_A.rvt | 2.5
927219 | 1DC1 | 8 | <not associated> | 2.5
927229 | 1DC1 | 8 | <not associated> | 2.5

# IfcFlowTerminal: M175, M_Surface Mounted Light:M175:M175:779006
In: 2A14
Type - ElementType: M175; Classification:  (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Constraints - Default Elevation: 1.2 m; Host: Linked Revit Model : Clinic_A.rvt; Elevation: 2.68 m
Electrical - Loads - Apparent Load: 1614.59; Panel: L42C; Circuit Number: 7
Materials and Finishes - Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy; Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance
Photometrics - Initial Color: 0; Light Loss Factor: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215; Initial Intensity: 0; Lumens: 14000; Light Source Definition (family): Point+HemiSpherical
Dimensions - Light Source Symbol Size: 0.05 m; Light Casing Length: 2.4 m; Drop From Ceiling: 0.1 m
Identity Data - OmniClass Number: 23.80.70.11.11; Type Mark: M175; Description: SURFACE MOUNTED METAL HALIDE FIXTURE; OmniClass Title: General Luminaries, Non Directional; Manufacturer: N/A
Electrical - Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67; Wattage Comments: 175; Lamp: METAL HALIDE; Ballast Number of Poles: 1
Other - SensibleLoadToRadiant: 0; Grade: N/A; ExpectedLife: N/A; ModelReference: N/A; MaximumPlenumSensibleLoad: 0; MaintenanceFactor: 0; RatedCurrent: 0; ModelLabel: N/A; NominalWidth: 0; WarrantyDurationLabor: N/A; NumberOfPoles: 0; AssetAccountingType: FIXED; ConductorFunction: L1; Material: N/A; Features: N/A; WarrantyGuarantorParts: N/A; WarrantyGuarantorLabor: N/A; IP_Code: 0; ProductionYear: N/A; TotalWattage: 0; ReplacementCost: N/A; MaximumSpaceSensibleLoad: 0; HasProtectiveEarth: TRUE; WarrantyDurationParts: N/A; WarrantyDescription: N/A; RatedVoltage: 0; NominalHeight: 0; Shape: N/A; CodePerformance: N/A; NominalLength: 0; PowerFactor: 0; SustainabilityPerformance: N/A; AccessibilityPerformance: N/A; Size: 0; NominalFrequencyRange: 0; NumberOfSources: 0; Constituents: N/A; Schedule Level: Level: Level 2; WarrantyStartDate: N/A; InstallationDate: N/A; Reference: REF TYPE MARK; BarCode: N/A; SerialNumber: N/A; AssetIdentifier: N/A; TagNumber: N/A; BackupSupplySystem: NO; FixtureHeight: 0
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-150 VA
Phasing - Phase Created: New Construction

# IfcFlowTerminal: M250, M_Surface Mounted Light:M250:M250:782392
In: 2D03
Type - ElementType: M250; Classification:  (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Dimensions - Drop From Ceiling: 0.1 m; Light Casing Length: 2.4 m; Light Source Symbol Size: 0.05 m
Photometrics - Initial Intensity: 0; Light Loss Factor: 0; Dimming Lamp Color Temperature Shift: 0; Lumens: 20500; Color Filter: 16777215; Light Source Definition (family): Point+HemiSpherical; Initial Color: 0
Electrical - Loads - Apparent Load: 1614.59; Panel: L42B; Circuit Number: 2
Identity Data - Description: SURFACE MOUNTED METAL HALIDE FIXTURE; Manufacturer: N/A; OmniClass Title: General Luminaries, Non Directional; Type Mark: M250; OmniClass Number: 23.80.70.11.11
Materials and Finishes - Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy
Electrical - Wattage Comments: 250; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67; Lamp: METAL HALIDE; Ballast Number of Poles: 1
Constraints - Default Elevation: 1.2 m; Host: Linked Revit Model : Clinic_A.rvt; Elevation: 2.68 m
Other - NominalHeight: 0; Grade: N/A; WarrantyGuarantorParts: N/A; NominalLength: 0; NumberOfSources: 0; Constituents: N/A; Size: 0; ModelReference: N/A; Material: N/A; ExpectedLife: N/A; WarrantyDurationLabor: N/A; NominalFrequencyRange: 0; MaximumSpaceSensibleLoad: 0; PowerFactor: 0; ConductorFunction: L1; CodePerformance: N/A; MaximumPlenumSensibleLoad: 0; HasProtectiveEarth: TRUE; ReplacementCost: N/A; RatedVoltage: 0; Shape: N/A; TotalWattage: 0; Features: N/A; WarrantyDescription: N/A; SustainabilityPerformance: N/A; RatedCurrent: 0; AssetAccountingType: FIXED; ModelLabel: N/A; SensibleLoadToRadiant: 0; MaintenanceFactor: 0; AccessibilityPerformance: N/A; NumberOfPoles: 0; WarrantyDurationParts: N/A; WarrantyGuarantorLabor: N/A; IP_Code: 0; ProductionYear: N/A; NominalWidth: 0; SerialNumber: N/A; WarrantyStartDate: N/A; Schedule Level: Level: Level 2; Reference: REF TYPE MARK; BackupSupplySystem: NO; AssetIdentifier: N/A; BarCode: N/A; InstallationDate: N/A; FixtureHeight: 0; TagNumber: N/A
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-150 VA

# IfcFlowTerminal: M400 (3)
Type - ElementType: M400; Classification:  (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Electrical - Wattage Comments: 400; Ballast Number of Poles: 1; Ballast Voltage: 1291.67; Lamp: METAL HALIDE; Load Classification: Lighting - Dwelling Unit
Dimensions - Light Casing Length: 2.4 m; Drop From Ceiling: 0.1 m; Light Source Symbol Size: 0.05 m
Constraints - Default Elevation: 1.2 m
Identity Data - OmniClass Title: General Luminaries, Non Directional; Type Mark: M400; Description: SURFACE MOUNTED METAL HALIDE FIXTURE; Manufacturer: N/A; OmniClass Number: 23.80.70.11.11
Photometrics - Lumens: 36000; Color Filter: 16777215; Dimming Lamp Color Temperature Shift: 0; Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Color: 0; Initial Intensity: 0
Electrical - Loads - Apparent Load: 1614.59; Panel: L42B; Circuit Number: 2
Materials and Finishes - Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy
Other - CodePerformance: N/A; RatedCurrent: 0; NumberOfSources: 0; ConductorFunction: L1; WarrantyDurationParts: N/A; Material: N/A; NumberOfPoles: 0; SustainabilityPerformance: N/A; WarrantyDurationLabor: N/A; Grade: N/A; Size: 0; NominalHeight: 0; MaximumPlenumSensibleLoad: 0; Features: N/A; NominalFrequencyRange: 0; Shape: N/A; ModelReference: N/A; SensibleLoadToRadiant: 0; TotalWattage: 0; NominalLength: 0; PowerFactor: 0; Constituents: N/A; WarrantyGuarantorParts: N/A; MaintenanceFactor: 0; ProductionYear: N/A; AssetAccountingType: FIXED; RatedVoltage: 0; HasProtectiveEarth: TRUE; ModelLabel: N/A; WarrantyDescription: N/A; MaximumSpaceSensibleLoad: 0; ExpectedLife: N/A; AccessibilityPerformance: N/A; WarrantyGuarantorLabor: N/A; NominalWidth: 0; ReplacementCost: N/A; IP_Code: 0; Reference: REF TYPE MARK; SerialNumber: N/A; Schedule Level: Level: Level 2; BarCode: N/A; InstallationDate: N/A; FixtureHeight: 0; TagNumber: N/A; WarrantyStartDate: N/A; AssetIdentifier: N/A; BackupSupplySystem: NO
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-150 VA
Name (M_Surface Mounted Light:M400:M400:...) | In | Host | Elevation (m)
782453 | 2D03 | <not associated> | 2.8
782613 | 2D04-A | Linked Revit Model : Clinic_A.rvt | 2.68
782665 | 2D04-A | Linked Revit Model : Clinic_A.rvt | 2.68

# IfcFlowTerminal: P1 - Length as Shown (13)
Type - ElementType: P1 - Length as Shown; Classification:  (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Constraints - Default Elevation: 1.2 m; Host: Linked Revit Model : Clinic_A.rvt
Electrical - Loads - Apparent Load: 1614.59
Identity Data - OmniClass Title: General Luminaries, Non Directional; OmniClass Number: 23.80.70.11.11; Type Mark: P1; Manufacturer: N/A; Description: LINEAR FLOURESCENT UPLIGHT FIXTURE. ONE PIECE EXTRUDED ALUMINUM CONSTRUCTION. PENDANT MOUNTED. LENGTH AS SHOWN ON DRAWINGS. COORDINATE FINISH WITH CONTRACTING OFFICER. MOUNT 458mm FROM CEILING TO BOTTOM OF FIXTURE.
Electrical - Ballast Number of Poles: 1; Lamp: T8, 1219mm, RAPID START, CRI=75; Ballast Voltage: 1291.67; Load Classification: Lighting - Dwelling Unit; Wattage Comments: 32
Dimensions - Drop From Ceiling: 0.3 m; Light Source Symbol Size: 0.05 m; Light Casing Length: 2.4 m
Materials and Finishes - Diffuser Material: Glass - White, High Luminance; Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy
Photometrics - Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Lumens: 2900; Initial Intensity: 0; Dimming Lamp Color Temperature Shift: 0; Initial Color: 0; Color Filter: 16777215
Other - MaximumSpaceSensibleLoad: 0; WarrantyGuarantorLabor: N/A; RatedCurrent: 0; PowerFactor: 0; NumberOfSources: 0; AccessibilityPerformance: N/A; SensibleLoadToRadiant: 0; Material: N/A; NumberOfPoles: 0; NominalLength: 0; HasProtectiveEarth: TRUE; MaximumPlenumSensibleLoad: 0; Grade: N/A; SustainabilityPerformance: N/A; MaintenanceFactor: 0; AssetAccountingType: FIXED; ProductionYear: N/A; Shape: N/A; WarrantyDurationParts: N/A; NominalFrequencyRange: 0; TotalWattage: 0; ReplacementCost: N/A; Features: N/A; CodePerformance: N/A; NominalHeight: 0; Size: 0; WarrantyDescription: N/A; ModelLabel: N/A; IP_Code: 0; NominalWidth: 0; WarrantyDurationLabor: N/A; ConductorFunction: L1; ExpectedLife: N/A; Constituents: N/A; ModelReference: N/A; WarrantyGuarantorParts: N/A; RatedVoltage: 0; AssetIdentifier: N/A; WarrantyStartDate: N/A; TagNumber: N/A; InstallationDate: N/A; SerialNumber: N/A; BarCode: N/A; BackupSupplySystem: NO; FixtureHeight: 0; Reference: REF TYPE MARK
Electrical - Circuiting - Electrical Data: 120 V/1-150 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Name (M_Pendant Light - Linear:P1 - Length as Shown:P1 - Length as Shown:...) | In | Schedule Level | Elevation (m) | Circuit Number | Panel
746278 | 1DC1 | Level: Level 1 | 2.8 | 6 | L41C
746342 | 1DC1 | Level: Level 1 | 2.8 | 6 | L41C
746382 | 1DC1 | Level: Level 1 | 2.8 | 6 | L41C
746439 | 1DC1 | Level: Level 1 | 2.68 | 6 | L41C
746494 | 1DC1 | Level: Level 1 | 2.68 | 6 | L41C
746528 | 1DC1 | Level: Level 1 | 2.68 | 6 | L41C
746576 | 1DC1 | Level: Level 1 | 2.68 | 6 | L41C
777306 | 2D18 | Level: Level 2 | 2.68 | 5 | L42B
777413 | 2D18 | Level: Level 2 | 2.68 | 5 | L42B
777540 | 2D18 | Level: Level 2 | 2.68 | 5 | L42B
777566 | 2D18 | Level: Level 2 | 2.68 | 5 | L42B
777702 | 2D18 | Level: Level 2 | 2.68 | 5 | L42B
777758 | 2D18 | Level: Level 2 | 2.68 | 5 | L42B

# IfcFlowTerminal: Q1 - 1219mm (6)
Type - ElementType: Q1 - 1219mm; Classification:  (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Electrical - Loads - Apparent Load: 1614.59
Constraints - Default Elevation: 1.2 m
Dimensions - Light Casing Length: 2.4 m; Drop From Ceiling: 0.3 m; Light Source Symbol Size: 0.05 m
Identity Data - Manufacturer: N/A; Type Mark: Q1; OmniClass Title: General Luminaries, Non Directional; Description: 1219mm SINGLE LAMP STRIP, WITH WIRE GUARD. MOUNT 2438mm AFF.; OmniClass Number: 23.80.70.11.11
Electrical - Ballast Number of Poles: 1; Ballast Voltage: 1291.67; Wattage Comments: 32; Lamp: T8, 1219mm, RAPID START, CRI=75; Load Classification: Lighting - Dwelling Unit
Other - NominalLength: 0; Grade: N/A; Constituents: N/A; NominalFrequencyRange: 0; WarrantyGuarantorLabor: N/A; NumberOfPoles: 0; MaximumSpaceSensibleLoad: 0; SensibleLoadToRadiant: 0; ModelReference: N/A; ExpectedLife: N/A; Shape: N/A; CodePerformance: N/A; MaintenanceFactor: 0; NominalHeight: 0; IP_Code: 0; NominalWidth: 0; ReplacementCost: N/A; HasProtectiveEarth: TRUE; ModelLabel: N/A; Size: 0; WarrantyDurationParts: N/A; Material: N/A; RatedCurrent: 0; PowerFactor: 0; TotalWattage: 0; Features: N/A; WarrantyDescription: N/A; ProductionYear: N/A; SustainabilityPerformance: N/A; AssetAccountingType: FIXED; NumberOfSources: 0; AccessibilityPerformance: N/A; WarrantyGuarantorParts: N/A; WarrantyDurationLabor: N/A; ConductorFunction: L1; RatedVoltage: 0; MaximumPlenumSensibleLoad: 0; TagNumber: N/A; BackupSupplySystem: NO; BarCode: N/A; InstallationDate: N/A; Reference: REF TYPE MARK; FixtureHeight: 0; AssetIdentifier: N/A; WarrantyStartDate: N/A; SerialNumber: N/A
Photometrics - Color Filter: 16777215; Light Loss Factor: 0; Dimming Lamp Color Temperature Shift: 0; Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Initial Intensity: 0; Lumens: 2900
Materials and Finishes - Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-150 VA
Name (M_Pendant Light - Linear:Q1 - 1219mm:Q1 - 1219mm:...) | In | Schedule Level | Circuit Number | Panel | Host | Elevation (m)
745294 | 1B16 | Level: Level 1 | 1 | L41B | Linked Revit Model : Clinic_A.rvt | 2.68
825912 | 1D17 | Level: Level 1 | 5 | L41C | Linked Revit Model : Clinic_A.rvt | 2.68
826740 | 1A11 | Level: Level 1 | 24 | N21C1 | <not associated> | 2.8
843057 | 2B2 | Level: Level 2 | 1 | L42B | <not associated> | 4.68
849854 | 2C05 | Level: Level 2 | 2 | L42C | Linked Revit Model : Clinic_S.rvt | 4.68
850985 | 2B20 | Level: Level 2 | 1 | L42B | <not associated> | 2.8

# IfcFlowTerminal: Q4 - 1219mm - 1m Drop (38)
Type - ElementType: Q4 - 1219mm - 1m Drop; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Electrical - Loads - Apparent Load: 688.89
Materials and Finishes - Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy; Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance
Constraints - Default Elevation: 1.2 m
Photometrics - Lumens: 2900; Color Filter: 16777215; Initial Intensity: 0; Light Source Definition (family): Point+HemiSpherical; Dimming Lamp Color Temperature Shift: 0; Initial Color: 0; Light Loss Factor: 0
Dimensions - Light Casing Length: 1.2 m; Drop From Ceiling: 2 m; Light Source Symbol Size: 0.05 m
Electrical - Wattage Comments: 32; Lamp: T8, 1219mm, RAPID START, CRI=75 T8, 1219mm, RAPID START, CRI=75 T8, 1219mm, RAPID START, CRI=75; Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67
Other - ExpectedLife: N/A; RatedVoltage: 0; NominalWidth: 0; ReplacementCost: N/A; Shape: N/A; ModelLabel: N/A; RatedCurrent: 0; ProductionYear: N/A; AssetAccountingType: FIXED; Grade: N/A; NominalFrequencyRange: 0; TotalWattage: 0; NominalLength: 0; NominalHeight: 0; WarrantyDescription: N/A; CodePerformance: N/A; WarrantyDurationParts: N/A; NumberOfPoles: 0; SustainabilityPerformance: N/A; WarrantyDurationLabor: N/A; Size: 0; HasProtectiveEarth: TRUE; ModelReference: N/A; AccessibilityPerformance: N/A; PowerFactor: 0; IP_Code: 0; Material: N/A; NumberOfSources: 0; WarrantyGuarantorLabor: N/A; Constituents: N/A; MaximumPlenumSensibleLoad: 0; MaintenanceFactor: 0; WarrantyGuarantorParts: N/A; Features: N/A; ConductorFunction: L1; MaximumSpaceSensibleLoad: 0; SensibleLoadToRadiant: 0; BackupSupplySystem: NO; WarrantyStartDate: N/A; SerialNumber: N/A; AssetIdentifier: N/A; InstallationDate: N/A; FixtureHeight: 0; BarCode: N/A; TagNumber: N/A; Reference: REF TYPE MARK
Identity Data - Type Mark: Q4; Assembly Description: Lighting - Fluorescent; Assembly Code: D5020210; OmniClass Title: General Luminaries, Non Directional; OmniClass Number: 23.80.70.11.11; Manufacturer: N/A; Description: 1219mm TWO LAMP STRIP, WITH WIRE GUARD. MOUNT 2438mm AFF.
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-64 VA
Phasing - Phase Created: New Construction
Name (M_Pendant Light - Linear:Q4 - 1219mm - 1m Drop:Q4 - 1219mm - 1m Drop:...) | In | Schedule Level | Host | Elevation (m) | Panel | Circuit Number
744180 | 1C13 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
744273 | 1C13 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
744703 | 1E15 | Level: Level 1 | <not associated> | 2.8 | L41B | 5
744869 | 1E15 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 5
744933 | 1E15 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 5
745757 | 1E20 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 6
745874 | 1E21 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 6
745992 | 1E19 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 6
750622 | 1B21 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 1
750727 | 1B23 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 8
774134 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
774298 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.6735 | L42C | 9
774451 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
774522 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
774621 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
774680 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
774744 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
774911 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
774993 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775091 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775170 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775226 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775261 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775330 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775447 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775523 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775602 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775734 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775855 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
775907 | 2D05 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.68 | L42C | 9
776509 | 2B13 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 3
776627 | 2B12 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 3
783310 | 2C18 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.6735 | L42C | 1
783320 | 2C15 | Level: Level 2 | Linked Revit Model : Clinic_S.rvt | 4.6735 | L42C | 1
825760 | 1C03 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
826248 | 1E02 | Level: Level 1 | <not associated> | 2.8 | L41B | 3
