Properties of the parts of a building model (IFC2X3), part 6 of 7

# IfcFlowTerminal: Standard (958)
Name (M_Duplex Receptacle:Standard:Standard:...) | In | Schedule Level | Elevation (m) | Host | Circuit Number | Panel | Mark
868266 | 1CC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21C | 61
868304 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21C | 62
868347 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21C | 63
868390 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21C | 64
868426 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21C | 65
868524 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21C | 66
868587 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21C | 67
868686 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C | 68
868775 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C | 70
868817 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C | 71
868938 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C | 72
868963 | 1C10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C | 73
869018 | 1C02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C | 74
869082 | 1C02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C | 75
869126 | 1C02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C | 76
869190 | 1C02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C | 77
869273 | 1C01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C | 78
869317 | 1C07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21C | 79
869402 | 1CC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C | 80
869482 | 1C17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21C | 81
869589 | 1C17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21C | 82
869643 | 1C17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21C | 83
869696 | 1C17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21C | 84
869760 | 1D16 | Level: Level 1 | 0.5 | Grid : F | 17 | N21C1 | 85
869970 | 1D16 | Level: Level 1 | 0.5 | Grid : F | 17 | N21C1 | 86
870054 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21C1 | 87
870118 | 1D16 | Level: Level 1 | 0.5 | <not associated> | 18 | N21C1 | 88
870278 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21C1 | 89
870465 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21C1 | 90
870508 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21C1 | 91
870551 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21C1 | 92
870604 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21C1 | 93
870719 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21C1 | 94
870773 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21C1 | 95
870910 | 1D20 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C1 | 96
870975 | 1D20 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C1 | 97
871038 | 1D21 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21C1 | 98
871112 | 1D21 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21C1 | 99
871216 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C1 | 100
871280 | 1D17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C1 | 101
871422 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C1 | 102
871598 | 1D07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21C1 | 103
872113 | 1D07 | Level: Level 1 | 0.5 | Grid : F | 2 | N21C1 | 104
872166 | 1D07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21C1 | 105
872221 | 1D07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21C1 | 106
872376 | 1D07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21C1 | 107
872432 | 1D07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21C1 | 108
872448 | 1D07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21C1 | 109
872491 | 1D06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21C1 | 110
872567 | 1D06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21C1 | 111
872642 | 1D05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21C1 | 112
872686 | 1D05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21C1 | 113
872729 | 1D05 | Level: Level 1 | 0.5 | Grid : F | 5 | N21C1 | 114
872772 | 1D05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21C1 | 115
872827 | 1D05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21C1 | 116
873042 | 1D05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21C1 | 117
873145 | 1D05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21C1 | 118
873218 | 1D05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21C1 | 119
873261 | 1D05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21C1 | 120
873399 | 1D04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21C1 | 121
873452 | 1DC3 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21C1 | 122
873751 | 1D03 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21C1 | 123
873814 | 1AC2 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21B1 | 124
873900 | 1C07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21C | 125
874228 | 1C07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21C | 126
874291 | 1C07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21C | 127
874334 | 1C07 | Level: Level 1 | 0.5 | Grid : 4 | 21 | N21C | 128
874378 | 1C07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21C | 129
874442 | 1C07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21C | 130
874871 | 1C07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21C | 131
874895 | 1C07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21C | 132
875010 | 1C07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21C | 133
875039 | Level 1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N21B1 | 134
875275 | 1A09 | Level: Level 1 | 0.5 | Grid : G | 23 | N21B1 | 135
875401 | 1AC3 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N21B1 | 136
875506 | 1A08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21B1 | 137
875890 | 1A08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21B1 | 138
875966 | 1A10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21B1 | 139
876010 | 1A08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21B1 | 140
876106 | 1A08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21B1 | 141
876149 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21B1 | 142
876192 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N21B1 | 143
876286 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N21B1 | 144
876400 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N21B1 | 145
876568 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N21B1 | 146
876611 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N21B1 | 147
876815 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N21B1 | 148
876919 | 1A07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21B1 | 149
877106 | 1A07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21B1 | 150
877150 | 1A07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21B1 | 151
877193 | 1A07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21B1 | 152
877236 | 1A07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21B1 | 153
877290 | 1A05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21B1 | 154
877363 | 1A05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21B1 | 155
877426 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21B1 | 156
877469 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21B1 | 157
877644 | 1A05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21B1 | 158
877728 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21B1 | 159
877772 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21B1 | 160
877816 | 1A03 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21B1 | 161
877860 | 1A03 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21B1 | 162
877904 | 1A03 | Level: Level 1 | 0.5 | M_Lighting Switches : Single Pole | 13 | N21B1 | 163
878031 | 1A03 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21B1 | 164
878085 | 1A03 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21B1 | 165
878129 | 1A01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21B1 | 166
878213 | 1A01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N21B1 | 167
878256 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21B1 | 168
878329 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21B1 | 169
878372 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21B1 | 170
878501 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21B1 | 171
878544 | 1A01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21B1 | 172
878678 | 1A01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21B1 | 173
878792 | 1A01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21B1 | 174
878947 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21B1 | 175
878990 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21B1 | 176
879033 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21B1 | 177
879441 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21B1 | 178
879636 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21B1 | 179
879659 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21B1 | 180
879796 | 1A06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21B1 | 181
880544 | 1A06 | Level: Level 1 | 0.5 | Grid : G | 18 | N21B1 | 182
880597 | 1A06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21B1 | 183
880693 | 1A06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21B1 | 184
880841 | 1A06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21B1 | 185
880885 | 1A04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21B1 | 186
880950 | 1A04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21B1 | 187
881014 | 1A04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21B1 | 188
881128 | 1A04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21B1 | 189
881202 | 1AC5 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21B1 | 190
881287 | 1A02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21B1 | 191
881371 | 1A02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21B1 | 192
881424 | 1A02 | Level: Level 1 | 0.5 | Grid : 1 | 14 | N21B1 | 193
881528 | 1A02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21B1 | 194
881889 | 1A02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21B1 | 195
882190 | 1A02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21B1 | 196
882318 | 1A02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21B1 | 197
882529 | 1A02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21B1 | 198
882999 | 1AC1 | Level: Level 1 | 0.5 | Grid : D.9 | 2 | N21B1 | 199
883272 | Level 1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21B1 | 200
883499 | Level 1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21B1 | 201
883657 | 1AC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21B1 | 202
883835 | 1AC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21B1 | 203
884012 | 1B01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21B | 204
884298 | 1B01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21B | 205
884423 | 1B01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21B | 206
884519 | 1B01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21B | 207
884698 | 1B01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21B | 208
884802 | 1B01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21B | 209
884896 | 1B02 | Level: Level 1 | 0.5 | M_Lighting Switches : Single Pole | 17 | N21B | 210
885156 | 1BC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21B | 211
885220 | 1B03 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21B | 212
885451 | 1B03 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21B | 213
886106 | 1B03 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21B | 214
886255 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21B | 215
886360 | 1B05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21B | 216
886424 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21B | 217
886468 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21B | 218
886522 | 1B07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21B | 219
886710 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21B | 220
886763 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21B | 221
886806 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21B | 222
886960 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N21B | 223
887170 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N21B | 224
887213 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21B | 225
887484 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21B | 226
887569 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21B | 227
887737 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21B | 228
887883 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21B | 229
887927 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21B | 230
888014 | 1B06 | Level: Level 1 | 0.5 | M_Lighting Switches : Single Pole | 20 | N21B | 231
888064 | 1B08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21B | 232
888107 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21B | 233
888152 | 1B11 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21B | 234
888207 | 1B06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N21B | 235
888374 | 1B06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N21B | 236
888399 | 1B06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N21B | 237
888453 | 1B06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N21B | 238
888578 | 1B08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21B | 239
888778 | 1B10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21B | 240
889038 | 1B10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21B | 241
889073 | 1B10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21B | 242
889193 | 1B10 | Level: Level 1 | 0.65 | Linked Revit Model : Clinic_A.rvt | 11 | N21B | 243
889222 | 1B10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21B | 244
889364 | 1B10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21B | 245
889426 | 1B12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21B | 246
889712 | 1B14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21B | 247
889817 | 1B16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21B | 248
889966 | Level 1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21B | 249
890125 | 1E29 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21E2 | 250
890210 | 1E01 | Level: Level 1 | 0.5 | Grid : 4 | 8 | N21E2 | 251
890353 | 1E01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21E2 | 252
890397 | 1E04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21E2 | 253
890461 | 1BC4 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21B | 254
890615 | 1B23 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N21B | 255
890740 | 1B21 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21B | 256
890991 | 1B17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21B | 257
891157 | 1B17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21B | 258
891210 | 1B17 | Level: Level 1 | 0.5 | Grid : C.5 | 3 | N21B | 259
891357 | 1B13 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21B | 260
891401 | 1B17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21B | 261
891557 | 1A10 | Level: Level 1 | 0.65 | Linked Revit Model : Clinic_A.rvt | 24 | N21B1 | 262
891605 | 1A16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N21B1 | 263
891648 | 1A10 | Level: Level 1 | 0.5 | Orphaned | 22 | N21B1 | 264
891721 | 1AC4 | Level: Level 1 | 0.5 | Orphaned | 20 | N21B1 | 265
891765 | 1A12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N21B1 | 266
891830 | 1A14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21B1 | 267
892376 | 1A14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21B1 | 268
892440 | 1A14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21B1 | 269
892484 | 1A15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21B1 | 270
892671 | 1A15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21B1 | 271
892836 | 1A15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21B1 | 272
892880 | 1A15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21B1 | 273
893004 | 1AC1 | Level: Level 1 | 0.5 | Grid : D.9 | 3 | N21B1 | 274
893077 | 1A01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21B1 | 275
893532 | 1AC1 | Level: Level 1 | 0.5 | Grid : D.9 | 2 | N21B1 | 276
893626 | 1AC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21B1 | 277
894123 | 1B13 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21B | 278
894198 | 1B13 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21B | 279
894253 | 1B15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21B | 280
894338 | 1BC2 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21B | 281
894656 | 1B15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21B | 282
894825 | 1B09 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21B | 283
895058 | 1B04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21B | 284
895130 | 1BC3 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21B | 285
895427 | 1E28 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21E2 | 286
895960 | 1E28 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21E2 | 287
896014 | 1E28 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21E2 | 288
896097 | 1E28 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21E2 | 289
896141 | 1E27 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E2 | 290
896185 | 1E27 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E2 | 291
896228 | 1E27 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E2 | 292
896282 | 1E26 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E2 | 293
896335 | 1E26 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E2 | 294
896385 | 1E26 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E2 | 295
896439 | 1E26 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E2 | 296
896476 | 1E26 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E2 | 297
896549 | 1E26 | Level: Level 1 | 0.5 | M_Lighting Switches : Single Pole | 11 | N21E2 | 298
896593 | 1E26 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E2 | 299
896703 | 1E29 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21E2 | 300
896782 | 1E29 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21E2 | 301
896867 | 1E29 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21E2 | 302
896917 | 1E25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21E2 | 303
897085 | 1E25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21E2 | 304
897109 | 1E25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21E2 | 305
897232 | 1E25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E2 | 306
897262 | 1E24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E2 | 307
897296 | 1E25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E2 | 308
897406 | 1E25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21E2 | 309
897584 | 1E24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21E2 | 310
897699 | 1E24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21E2 | 311
897905 | 1E24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21E2 | 312
898070 | 1E24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21E2 | 313
898098 | 1E23 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E2 | 314
898273 | 1E24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E2 | 315
898319 | 1E30 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E2 | 316
898358 | 1E24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21E2 | 317
898520 | 1E24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21E2 | 318
898544 | 1E22 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E2 | 319
898582 | 1E20 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E2 | 320
898626 | 1E24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21E2 | 321
898853 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N21E2 | 322
899248 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N21E2 | 323
899774 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N21E2 | 324
899818 | 1E16 | Level: Level 1 | 0.5 | <not associated> | 24 | N21E2 | 325
899929 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N21E2 | 326
899961 | 1E16 | Level: Level 1 | 0.5 | <not associated> | 25 | N21E2 | 327
899992 | 1E16 | Level: Level 1 | 0.5 | <not associated> | 23 | N21E2 | 328
900026 | 1E18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21E2 | 329
900128 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21E2 | 330
900165 | 1E18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21E2 | 331
900244 | 1E18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21E2 | 332
900268 | 1E18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21E2 | 333
900292 | 1E18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21E2 | 334
900321 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21E2 | 335
900345 | 1E18 | Level: Level 1 | 0.5 | M_Lighting and Appliance Panelboard - 208V MLO : F41E | 19 | N21E2 | 336
900402 | 1E18 | Level: Level 1 | 0.5 | M_Lighting and Appliance Panelboard - 208V MLO : F21E | 19 | N21E2 | 337
900568 | 1E16 | Level: Level 1 | 0.5 | M_Lighting and Appliance Panelboard - 208V MLO : N21E1 | 16 | N21E2 | 338
900578 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21E2 | 339
900886 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21E2 | 340
900911 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21E2 | 341
900935 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21E2 | 342
901019 | 1E16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21E2 | 343
901093 | Level 1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N21E2 | 344
901157 | 1E19 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E2 | 345
901283 | 1EC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N21E2 | 346
901377 | 1E14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N21E2 | 347
901625 | 1E15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N21E2 | 348
901709 | 1EC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E2 | 349
902340 | 1E10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E2 | 350
902383 | 1E09 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E2 | 351
902558 | 1E07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E2 | 352
902631 | 1E07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E2 | 353
902668 | 1E11 | Level: Level 1 | 0.65 | Linked Revit Model : Clinic_A.rvt | 31 | N21E2 | 354
902759 | 1E11 | Level: Level 1 | 0.65 | Linked Revit Model : Clinic_A.rvt | 31 | N21E2 | 355
902812 | 1E11 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 31 | N21E2 | 356
902866 | 1E11 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 30 | N21E2 | 357
902975 | 1E07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E2 | 358
903030 | 1E07 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E2 | 359
903076 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21E2 | 360
903101 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21E2 | 361
903125 | 1E08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21E2 | 362
903176 | 1E08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21E2 | 363
903212 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E2 | 364
903391 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E2 | 365
903511 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E2 | 366
903614 | 1EC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E2 | 367
903688 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E2 | 368
903734 | 1E04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21E2 | 369
903780 | 1E04 | Level: Level 1 | 0.65 | Linked Revit Model : Clinic_A.rvt | 6 | N21E2 | 370
903809 | 1E04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21E2 | 371
904009 | 1E04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21E2 | 372
904184 | 1E05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21E2 | 373
904228 | 1E05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21E2 | 374
904400 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21E2 | 375
904429 | 1E05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21E2 | 376
904453 | 1E03 | Level: Level 1 | 0.5 | M_Lighting Switches : Single Pole | 8 | N21E2 | 377
904653 | 1E02 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21E2 | 378
905074 | 1D38 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N21E1 | 379
905149 | 1D38 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N21E1 | 380
905203 | 1D38 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N21E1 | 381
905277 | 1E05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21E2 | 382
905620 | 1D38 | Level: Level 1 | 0.5 | Orphaned | 24 | N21E1 | 383
905813 | 1E06 | Level: Level 1 | 0.5 | Grid : C | 5 | N21E2 | 384
906002 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21E2 | 385
906151 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21E2 | 386
906205 | 1E06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21E2 | 387
906309 | 1E08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21E2 | 388
906404 | 1E08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21E2 | 389
906447 | 1E08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 30 | N21E2 | 390
906563 | 1E11 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 30 | N21E2 | 391
906679 | 1E11 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 30 | N21E2 | 392
906845 | 1E11 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 30 | N21E2 | 393
906928 | 1E12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N21E2 | 394
907147 | 1E33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N21E2 | 395
907261 | 1E33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N21E2 | 396
907373 | 1EC3 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 30 | N21E2 | 397
907413 | 1E33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N21E2 | 398
907473 | 1E33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N21E2 | 399
907497 | 1E33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 29 | N21E2 | 400
907531 | 1D38 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N21E1 | 401
908206 | 1D38 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N21E1 | 402
908259 | 1D38 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N21E1 | 403
908486 | 1BC4 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21B | 404
908685 | 1D40 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21E1 | 405
908771 | 1D40 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21E1 | 406
908854 | 1D40 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21E1 | 407
908898 | 1DC7 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21E1 | 408
908952 | 1DC8 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21E1 | 409
909069 | 1D37 | Level: Level 1 | 0.5 | Grid : C.7 | 6 | N21E1 | 410
909234 | 1D40 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21E1 | 411
909320 | 1D40 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21E1 | 412
909364 | 1D40 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21E1 | 413
909712 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21E1 | 414
909747 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21E1 | 415
910107 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21E1 | 416
910129 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21E1 | 417
910193 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21E1 | 418
910470 | 1D33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21E1 | 419
910535 | 1D33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21E1 | 420
910579 | 1D33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21E1 | 421
910984 | 1D33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21E1 | 422
911049 | 1D31 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E1 | 423
911154 | 1D31 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E1 | 424
911268 | 1D31 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E1 | 425
911413 | 1D31 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E1 | 426
911456 | 1D31 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E1 | 427
911551 | 1D30 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E1 | 428
911635 | 1D31 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21E1 | 429
911740 | 1D30 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E1 | 430
911824 | 1D30 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E1 | 431
911979 | 1DC7 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E1 | 432
912033 | 1D30 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E1 | 433
912086 | 1D30 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21E1 | 434
912129 | 1D27 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21E1 | 435
912347 | 1D27 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21E1 | 436
912390 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E1 | 437
912782 | 1D26 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E1 | 438
912931 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E1 | 439
912995 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E1 | 440
913059 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E1 | 441
913102 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21E1 | 442
913145 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21E1 | 443
913238 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21E1 | 444
913391 | 1D23 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21E1 | 445
913475 | 1D23 | Level: Level 1 | 0.5 | Grid : D.1 | 15 | N21E1 | 446
913624 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E1 | 447
913699 | 1D24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E1 | 448
913774 | 1D24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E1 | 449
913827 | 1D24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E1 | 450
913870 | 1D24 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21E1 | 451
913913 | 1D23 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21E1 | 452
914028 | 1D23 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21E1 | 453
914081 | 1D23 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21E1 | 454
914344 | 1D23 | Level: Level 1 | 0.5 | Grid : D.1 | 15 | N21E1 | 455
914439 | 1D22 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21E1 | 456
915083 | 1D22 | Level: Level 1 | 0.5 | <not associated> | 15 | N21E1 | 457
915487 | 1D22 | Level: Level 1 | 0.5 | M_Lighting Switches : Single Pole | 19 | N21E1 | 458
916103 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21E1 | 459
916157 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21E1 | 460
916357 | 1D22 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21E1 | 461
916503 | 1D22 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N21E1 | 462
916534 | 1D22 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21E1 | 463
916580 | 1D22 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21E1 | 464
916748 | 1D22 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21E1 | 465
916970 | 1D22 | Level: Level 1 | 0.5 | Grid : D.9 | 15 | N21E1 | 466
917076 | 1DC1 | Level: Level 1 | 0.5 | Grid : D.9 | 19 | N21C1 | 467
917203 | 1D20 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C1 | 468
917246 | 1D21 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21C1 | 469
917289 | 1D20 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C1 | 470
917333 | 1D19 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21C1 | 471
917377 | 1D21 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21C1 | 472
917430 | 1D21 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21C1 | 473
917473 | 1D21 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21C1 | 474
918957 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N21E1 | 475
919516 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N21E1 | 476
919591 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N21E1 | 477
919745 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N21E1 | 478
919819 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N21E1 | 479
919903 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N21E1 | 480
919997 | 1E14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N21E2 | 481
920082 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21E1 | 482
920178 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21E1 | 483
920262 | 1E33 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 29 | N21E2 | 484
920346 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21E1 | 485
920545 | 1E15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N21E2 | 486
920631 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21E1 | 487
920903 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21E1 | 488
921057 | 1D19 | Level: Level 1 | 0.5 | Grid : 7 | 14 | N21C1 | 489
922307 | 1D19 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N21C1 | 490
922371 | 1D15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C1 | 491
922511 | 1D12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21C1 | 492
922656 | 1D12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21C1 | 493
922710 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C1 | 494
922817 | 1D15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C1 | 495
922941 | 1D12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21C1 | 496
923037 | 1D14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C1 | 497
923225 | 1D12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21C1 | 498
923401 | 1D12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21C1 | 499
923566 | 1D12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21C1 | 500
923609 | 1DC3 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21C1 | 501
923756 | 1D01 | Level: Level 1 | 0.5 | Grid : E.2 | 3 | N21C1 | 502
923928 | 1DC2 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21C1 | 503
923972 | 1DC1 | Level: Level 1 | 0.5 | Grid : D.9 | 10 | N21C1 | 504
924536 | 1DC1 | Level: Level 1 | 0.5 | Grid : D.9 | 10 | N21C1 | 505
924670 | 1DC1 | Level: Level 1 | 0.5 | Grid : D.9 | 10 | N21C1 | 506
924752 | 1DC1 | Level: Level 1 | 0.5 | Grid : D.9 | 3 | N21C1 | 507
925087 | 1DC1 | Level: Level 1 | 0.5 | Grid : D.9 | 4 | N21E1 | 508
925140 | 1AC2 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21B1 | 509
928706 | 1C01 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21C | 510
928837 | 1D16 | Level: Level 1 | 0.5 | Grid : F | 16 | N21C1 | 511
928897 | 1D16 | Level: Level 1 | 0.5 | Grid : F | 16 | N21C1 | 512
928950 | 1D18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C1 | 513
929097 | 1DC4 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C1 | 514
929170 | 1D15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C1 | 515
929699 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E1 | 516
930580 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E1 | 517
930768 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E1 | 518
930863 | 1DC1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21E1 | 519
931881 | 1D39 | Level: Level 1 | 0.5 | M_Lighting Switches : Single Pole | 6 | N21E1 | 520
932099 | 1D27 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21E1 | 521
932133 | 1D27 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21E1 | 522
932602 | 1D25 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N21E1 | 523
932703 | 1DC6 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N21E1 | 524
934056 | 1A05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21B1 | 525
934171 | 1A10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21B1 | 526
934216 | 1A13 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N21B1 | 527
934261 | 1A10 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N21B1 | 528
934477 | 1B17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21B | 529
934497 | 1B17 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21B | 530
934633 | 1BC4 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21B | 531
934822 | 1BC2 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21B | 532
934906 | 1B15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21B | 533
934961 | 1B13 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21B | 534
935031 | Level 1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21B | 535
940391 | 2B21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22B1 | 536
940477 | 2B21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22B1 | 537
940593 | 2B21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22B1 | 539
940819 | 2B21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22B1 | 540
940898 | 2B22 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22B1 | 541
941049 | 2B23 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22B1 | 543
941069 | 2B23 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22B1 | 544
941115 | 2B23 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22B1 | 545
941139 | 2B23 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22B1 | 546
941203 | 2B24 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22B1 | 547
941339 | 2B24 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22B1 | 548
941433 | 2B24 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22B1 | 549
941567 | 2B24 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22B1 | 550
941631 | 2B01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22B1 | 551
941789 | 2B01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22B1 | 552
941833 | 2B01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22B1 | 553
941909 | 2B01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22B1 | 554
941993 | 2B3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22B1 | 555
942128 | 2B3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22B1 | 556
942192 | 2B3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22B1 | 557
942288 | 2B3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22B1 | 558
942395 | 2B3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22B1 | 559
942470 | 2B4 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22B1 | 560
942677 | 2B4 | Level: Level 2 | 0.5 | M_Lighting Switches : Single Pole | 5 | N22B1 | 561
942752 | 2B4 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22B1 | 562
942806 | 2B4 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22B1 | 563
943343 | 2B7 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22B1 | 564
943593 | 2B7 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22B1 | 565
943637 | 2B7 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22B1 | 566
943681 | 2B7 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22B1 | 567
943724 | 2B9 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22B1 | 568
943911 | 2B9 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22B1 | 569
943954 | 2B9 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22B1 | 570
944059 | 2B11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22B1 | 571
944305 | 2B11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22B1 | 572
944589 | 2B11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22B1 | 573
944633 | 2B11 | Level: Level 2 | 0.5 | M_Duplex Receptacle : Standard | 26 | N22B1 | 574
944820 | 2B11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22B1 | 575
944924 | Level 2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22B | 576
945103 | 2B2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22B1 | 577
945432 | 2BC5 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22B1 | 578
945487 | 2B5 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22B1 | 579
945540 | 2BC4 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22B1 | 580
945785 | 2B25 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N22B1 | 581
945829 | 2B25 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N22B1 | 582
945873 | 2B25 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N22B1 | 583
945916 | 2B8 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N22B1 | 584
945960 | 2B8 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N22B1 | 585
946033 | 2B19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22B1 | 586
946088 | 2B17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 18 | N22B1 | 587
946152 | 2B17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 19 | N22B1 | 588
946195 | 2B8 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N22B1 | 589
946534 | 2BC5 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22B1 | 591
946632 | 2B8 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N22B1 | 592
946675 | 2B8 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N22B1 | 593
946759 | 2B8 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N22B1 | 594
946922 | 2B10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22B1 | 595
947215 | 2B10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22B1 | 596
947259 | 2B10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22B1 | 597
947303 | 2B10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22B1 | 598
947367 | 2B10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22B1 | 599
947410 | 2B14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22B1 | 600
947545 | 2B14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22B1 | 601
947620 | 2B14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22B1 | 602
947715 | 2B14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22B1 | 603
947809 | 2B15 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22B1 | 604
947883 | 2B15 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22B1 | 605
947967 | 2B17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 29 | N22B1 | 606
948017 | 2B17 | Level: Level 2 | 0.65 | Linked Revit Model : Clinic_A.rvt | 18 | N22B1 | 607
948136 | 2B17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22B1 | 608
948258 | 2B17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 29 | N22B1 | 609
948294 | 2B15 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22B1 | 610
948329 | 2B15 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22B1 | 611
948359 | 2B19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22B1 | 612
948719 | 2B19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22B1 | 613
948762 | 2B19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22B1 | 614
948817 | 2B19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22B1 | 615
948860 | 2B13 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22B1 | 616
949107 | 2B13 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22B1 | 617
949150 | 2B12 | Level: Level 2 | 0.5 | M_Lighting and Appliance Panelboard - 208V MLO : N22B2 | 28 | N22B1 | 618
949277 | 2BC6 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N22B1 | 619
949479 | 2BC1 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22B | 620
949777 | 2BC2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N22B1 | 621
949808 | 2BS2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22B1 | 622
949970 | 2BC2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N22B1 | 623
950065 | 2BC3 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22B1 | 624
950116 | 2B14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22B1 | 625
950293 | 2B16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22B1 | 626
950427 | 2B16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22B1 | 627
950471 | 2B16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22B1 | 628
950746 | 2B16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N22B1 | 629
950800 | 2B18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22B1 | 630
950844 | 2B18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22B1 | 631
950888 | 2B18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22B1 | 632
951045 | 2B18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22B1 | 633
951099 | 2B20 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N22B1 | 634
951881 | 2D20 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22B1 | 635
951930 | 2D20 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 1 | N22B1 | 636
952474 | 2D20 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 1 | N22B1 | 637
952578 | 2D20 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22B1 | 638
952622 | 2D20 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22B1 | 639
952661 | 2D21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22B | 640
952717 | 2D21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 27 | N22B | 641
952741 | 2D21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 29 | N22B | 642
952772 | 2D21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 29 | N22B | 643
952803 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22B | 644
952835 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22B | 645
952859 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 25 | N22B | 646
953087 | 2D21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22B1 | 647
953203 | 2D21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22B1 | 648
953246 | 2D21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22B1 | 649
953289 | 2D21 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22B1 | 650
953381 | 2D01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22B | 651
953583 | 2DC1 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22B | 652
953627 | 2D01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22B | 653
953710 | 2D01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22B | 654
953846 | 2D01 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 26 | N22B | 655
953911 | 2D02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22B | 656
953995 | 2D02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22B | 657
954079 | 2D02 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 24 | N22B | 658
954153 | 2D03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N22B | 659
954208 | 2D03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N22B | 660
954251 | 2D03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N22B | 661
954399 | 2D03 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 28 | N22B | 662
954543 | 2D04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22B | 663
955292 | 2D04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22B | 664
955335 | 2D04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22B | 665
955389 | 2D04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N22B | 666
955443 | 2D04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N22B | 667
955516 | 2D04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N22B | 668
955683 | 2D04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 23 | N22B | 669
956019 | 2D04 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 21 | N22B | 670
956083 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22B | 671
956147 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22B | 672
956302 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N22B | 673
956365 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22B | 674
956458 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 20 | N22B | 675
956521 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N22B | 676
956656 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N22B | 677
956769 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22B | 678
956862 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22B | 679
956935 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N22B | 680
957101 | 2DC1 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22B | 681
957280 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22B | 682
957374 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22B | 683
957417 | 2DC2 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 19 | N22B | 684
957501 | 2D04-A | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N22B | 685
957576 | 2D19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22B | 686
957852 | 2D19 | Level: Level 2 | 0.5 | Orphaned | 13 | N22B | 687
957925 | 2D19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 13 | N22B | 688
958230 | 2D19 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N22B | 689
958305 | 2D17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22B | 690
958370 | 2D17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 15 | N22B | 691
958689 | 2D17 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N22B | 692
958733 | 2D15 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22B | 693
958827 | 2D15 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 16 | N22B | 694
958880 | 2D17 | Level: Level 2 | 0.5 | Orphaned | 15 | N22B | 695
959112 | 2D15 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22B | 696
959158 | 2D15 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N22B | 697
959168 | 2D14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22B | 698
959203 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22B | 699
959242 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 14 | N22B | 700
959295 | 2D14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22B | 701
959358 | 2D14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22B | 702
959531 | 2D14 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N22B | 703
959586 | 2D16 | Level: Level 2 | 0.5 | Grid : 6.7 | 4 | N22B | 704
959800 | 2D16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22B | 705
959843 | 2D16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22B | 706
959886 | 2D16 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N22B | 707
959941 | 2D13 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N22B | 708
960228 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22B | 709
960302 | 2D12 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 18 | N22B | 710
960502 | 2D11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22B | 711
960532 | 2D11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 1 | N22B | 712
960795 | 2D11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 1 | N22B | 713
960949 | 2D11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 1 | N22B | 714
961003 | 2D11 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N22B | 715
961066 | 2D10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22B | 716
961109 | 2D10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22B | 717
961233 | 2D10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N22B | 718
961262 | 2D10 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N22B | 719
961306 | 2D09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22B | 720
961480 | 2D18 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N22B | 721
961808 | 2D09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_S.rvt | 5 | N22B | 722
961892 | 2D09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22B | 723
961956 | 2D09 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N22B | 724
962030 | 2D08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22B | 725
962084 | 2D08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22B | 726
962127 | 2D08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22B | 727
962171 | 2D08 | Level: Level 2 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N22B | 728
