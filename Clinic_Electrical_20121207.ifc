Properties of the parts of a building model (IFC2X3), part 1 of 7

# File
Description: ViewDefinition [CoordinationView]
File name: Clinic_MEP_20121207 - Electrical.ifc
Time: 2012-12-18T09:02:40
Written by: Autodesk Revit 2013
Made in: 20121003_2115(x64)

# IfcProject, 100001
LongName: ABC MEDICAL CLINIC; Phase: N/A

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 m

# IfcBuilding, Medical Clinic
LongName: Medical Clinic
Identity Data - Building Name: Medical Clinic; Organization Name: XYZ; Organization Description: XYZ TECHNOLOGIES; Author: KFA
Other - Reference: 001; Project Name: ABC MEDICAL CLINIC; Project Address: 1234 RIGHT WAY DRIVE CHICAGO, IL 60601; Project Status: N/A; Category Code: 11-21 15 00; Project Number: 100001; Client Name: ABC; Category Description: Outpatient Care Facility; Project Issue Date: 2000
Text - FireProtectionClass: CLASS A; YearOfLastRefurbishment: 2008; GrossPlannedArea: 6000; SprinklerProtectionAutomatic: YES; NetPlannedArea: 5000; IsLandmarked: NO; YearOfConstruction: 2001; Fuel: 500; NumberOfStoreys: 2; Steam: 250; Heat: 750; Water: 300; OccupancyType: Commercial; ConstructionMethod: NEW CONSTRUCTION; BuildingID: 100; SprinklerProtection: YES; IsPermanentID: 657645; Electricity: 250
Pset_BuildingCommon - BuildingID: 100; OccupancyType: Commercial; YearOfConstruction: 2001; NumberOfStoreys: 3

# IfcBuildingStorey (3)
In: Medical Clinic
Constraints - Elevation Base: 0
Graphics - Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no
Identity Data - Building Story: yes; Structural: no
Dimensions - Computation Height: 1.2 m
Other - Category Code: Floor
Name | LongName = Name | Elevation (m) | Constraints, Elevation (m)
Level 1 | Level 1 | -2.82087e-13 | 0
Level 2 | Level 2 | 4.57 | 4.57
Roof - Main | Roof - Main | 9.25 | 9.25

# IfcSpace (266)
InteriorOrExteriorSpace: INTERNAL
Other - RoomTag: RoomTag
Dimensions - Computation Height: 1.2 m
Phasing - Phase: New Construction
Name | In | LongName = Name | GSA BIM Area (m2) = Area (m2) | Base Offset (m) | Level | Limit Offset (m) | Upper Limit | OccupancyZoneName | FireAlarmZoneName | VentilationZoneName | Other, WallCovering = Pset_SpaceCommon, WallCovering | CirculationZoneName | Other, FloorCovering = Pset_SpaceCommon, FloorCovering | Category Code | LightingZoneName | LoadCapacity | Other, CeilingCovering = Pset_SpaceCommon, CeilingCovering | Category Description = OmniClass Table 13 Category | HistoricPreservationZoneName | Unbounded Height (m) | Perimeter (m) | Volume (m3) | Number | Reference
1AC1 | Level 1 | CENTRAL WAITING | 139.755 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-51 31 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Waiting Room | Historic Preservation Zone 1A | 4.57 | 75.3209 | 625.159 | 1AC1 | CENTRAL WAITING 1AC1
1AC2 | Level 1 | CORRIDOR | 19.605 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-85 11 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1A | 4.57 | 24.0652 | 87.28 | 1AC2 | CORRIDOR 1AC2
1AC3 | Level 1 | CORRIDOR | 16.2935 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-85 11 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1A | 4.57 | 21.4955 | 68.5881 | 1AC3 | CORRIDOR 1AC3
1AC4 | Level 1 | CORRIDOR | 9.55147 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-85 11 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1A | 4.57 | 13.7932 | 40.2144 | 1AC4 | CORRIDOR 1AC4
1AC5 | Level 1 | CORRIDOR | 20.3751 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-85 11 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1A | 4.57 | 32.975 | 87.8317 | 1AC5 | CORRIDOR 1AC5
1A01 | Level 1 | PATIENT ADMIN. RECEPT. | 19.7671 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-11 11 31 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Reception Space | Historic Preservation Zone 1A | 4.57 | 19.072 | 86.9074 | 1A01 | PATIENT ADMIN. RECEPT. 1A01
1A02 | Level 1 | RMO ANALYST | 27.6932 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-15 11 34 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1A | 4.57 | 26.5002 | 121.826 | 1A02 | RMO ANALYST 1A02
1A03 | Level 1 | TRICARE OFFICE | 8.87366 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-15 11 34 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1A | 4.57 | 11.957 | 37.2844 | 1A03 | TRICARE OFFICE 1A03
1A04 | Level 1 | TRICARE OFFICE | 9.54452 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-15 11 34 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1A | 4.57 | 12.369 | 39.2574 | 1A04 | TRICARE OFFICE 1A04
1A05 | Level 1 | TRICARE OFFICE | 8.99911 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-15 11 34 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1A | 4.57 | 12.192 | 37.9204 | 1A05 | TRICARE OFFICE 1A05
1A06 | Level 1 | TRICARE OFFICE | 10.4921 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-15 11 34 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1A | 4.57 | 13.0265 | 42.6276 | 1A06 | TRICARE OFFICE 1A06
1A07 | Level 1 | TRICARE OFFICE | 8.73012 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-15 11 34 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1A | 4.57 | 12.5275 | 36.4201 | 1A07 | TRICARE OFFICE 1A07
1A08 | Level 1 | PHARM. OFFICE | 10.4499 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-15 11 34 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1A | 4.57 | 12.989 | 43.4639 | 1A08 | PHARM. OFFICE 1A08
1A09 | Level 1 | W. TOILET | 10.8536 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-41 11 14 21 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1A | 4.57 | 13.3715 | 44.8673 | 1A09 | W. TOILET 1A09
1A10 | Level 1 | LOUNGE | 10.2725 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-51 11 21 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Break Room | Historic Preservation Zone 1A | 4.57 | 14.38 | 43.5026 | 1A10 | LOUNGE 1A10
1A11 | Level 1 | JAN. | 2.03661 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-75 11 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1A | 4.57 | 6.022 | 7.6713 | 1A11 | JAN. 1A11
1A12 | Level 1 | M. TOILET | 9.91049 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-41 11 14 21 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1A | 4.57 | 13.184 | 41.8015 | 1A12 | M. TOILET 1A12
1A13 | Level 1 | STAFF TOILET | 4.4685 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-41 11 14 21 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1A | 4.57 | 8.506 | 17.9939 | 1A13 | STAFF TOILET 1A13
1A14 | Level 1 | SUPER / NCOIC | 7.22988 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-15 11 34 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1A | 4.57 | 10.1474 | 30.8391 | 1A14 | SUPER / NCOIC 1A14
1A15 | Level 1 | COUNSELING | 6.39843 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-41 41 99 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1A | 4.57 | 10.157 | 26.8169 | 1A15 | COUNSELING 1A15
1DC1 | Level 1 | WAITING / ACTIVITY AREA | 182.28 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-51 31 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Waiting Room | Historic Preservation Zone 1D | 4.57 | 80.656 | 814.452 | 1DC1 | WAITING / ACTIVITY AREA 1DC1
1DC2 | Level 1 | CORRIDOR | 6.34736 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-85 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1D | 4.57 | 10.67 | 27.117 | 1DC2 | CORRIDOR 1DC2
1DC3 | Level 1 | CORRIDOR | 31.8109 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-85 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1D | 4.57 | 38.1194 | 135.522 | 1DC3 | CORRIDOR 1DC3
1DC4 | Level 1 | CORRIDOR | 15.0608 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-85 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1D | 4.57 | 20.1242 | 64.4377 | 1DC4 | CORRIDOR 1DC4
1CC1 | Level 1 | CORRIDOR | 42.6545 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-85 11 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1C | 4.57 | 49.386 | 183.872 | 1CC1 | CORRIDOR 1CC1
1CC2 | Level 1 | CORRIDOR | 8.23209 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-85 11 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1C | 4.57 | 12.0636 | 34.5926 | 1CC2 | CORRIDOR 1CC2
1CC3 | Level 1 | CORRIDOR | 11.4965 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-85 11 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1C | 4.57 | 15.7842 | 48.4793 | 1CC3 | CORRIDOR 1CC3
1C01 | Level 1 | WAITING | 11.8597 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-51 31 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Waiting Room | Historic Preservation Zone 1C | 4.57 | 13.5102 | 53.1793 | 1C01 | WAITING 1C01
1C02 | Level 1 | RECEPTION | 9.31934 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-11 11 31 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Reception Space | Historic Preservation Zone 1C | 4.57 | 12.2052 | 40.3012 | 1C02 | RECEPTION 1C02
1C03 | Level 1 | JAN. CL. | 4.1106 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-75 11 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1C | 4.57 | 8.924 | 16.2089 | 1C03 | JAN. CL. 1C03
1C04 | Level 1 | FITTING / DISP. | 10.1189 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-41 41 99 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1C | 4.57 | 12.623 | 42.0014 | 1C04 | FITTING / DISP. 1C04
1C05 | Level 1 | VISUAL FIELD | 11.3446 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-41 41 14 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Physical Examination Room | Historic Preservation Zone 1C | 4.57 | 14.538 | 46.1775 | 1C05 | VISUAL FIELD 1C05
1C06 | Level 1 | SOIL. UTL. / TRASH | 5.40043 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-75 41 14 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Soiled Storage Room Space | Historic Preservation Zone 1C | 4.57 | 9.3758 | 21.2683 | 1C06 | SOIL. UTL. / TRASH 1C06
1C07 | Level 1 | OPT. EXAM / OFF. | 17.5712 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-15 11 34 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1C | 4.57 | 20.7032 | 74.5046 | 1C07 | OPT. EXAM / OFF. 1C07
1C08 | Level 1 | SCREEN EYE TEST | 9.81776 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-41 41 14 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Physical Examination Room | Historic Preservation Zone 1C | 4.57 | 13.352 | 41.5809 | 1C08 | SCREEN EYE TEST 1C08
1C09 | Level 1 | FUNDUS CAMERA ROOM | 14.9278 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-41 41 31 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Scanning/Imaging Room | Historic Preservation Zone 1C | 4.57 | 16.234 | 62.9373 | 1C09 | FUNDUS CAMERA ROOM 1C09
1C10 | Level 1 | OPT. EXAM / OFF. | 18.2545 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-15 11 34 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1C | 4.57 | 20.8688 | 77.6049 | 1C10 | OPT. EXAM / OFF. 1C10
1D01 | Level 1 | SL. LIN. / TRASH | 2.00168 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-75 41 14 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Soiled Storage Room Space | Historic Preservation Zone 1D | 4.57 | 6.1929 | 7.59687 | 1D01 | SL. LIN. / TRASH 1D01
1D02 | Level 1 | INTERACTION STATION | 11.5298 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 13.802 | 48.9939 | 1D02 | INTERACTION STATION 1D02
1D03 | Level 1 | CLEAN U. | 2.35008 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-15 21 11 21 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Clean Room | Historic Preservation Zone 1D | 4.57 | 6.09322 | 9.54417 | 1D03 | CLEAN U. 1D03
1D04 | Level 1 | TOILET | 5.10462 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 11 14 21 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1D | 4.57 | 9.078 | 20.9342 | 1D04 | TOILET 1D04
1D05 | Level 1 | TRMT RM. DIRTY PROC. | 14.1331 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Treatment Room | Historic Preservation Zone 1D | 4.57 | 15.0667 | 61.3812 | 1D05 | TRMT RM. DIRTY PROC. 1D05
1D06 | Level 1 | SCOPE WASH / DECON. | 8.99752 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 11 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Grooming Spaces | Historic Preservation Zone 1D | 4.57 | 12.507 | 38.0019 | 1D06 | SCOPE WASH / DECON. 1D06
1D07 | Level 1 | INTERACTION STATION | 12.5663 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.397 | 53.6586 | 1D07 | INTERACTION STATION 1D07
1D08 | Level 1 | INTERACTION STATION | 12.8273 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.4329 | 54.6014 | 1D08 | INTERACTION STATION 1D08
1D09 | Level 1 | INTERACTION STATION | 12.7792 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.3048 | 54.5951 | 1D09 | INTERACTION STATION 1D09
1D10 | Level 1 | INTERACTION STATION | 12.7437 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.4329 | 54.3093 | 1D10 | INTERACTION STATION 1D10
1D11 | Level 1 | INTERACTION STATION | 12.698 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.779 | 54.2672 | 1D11 | INTERACTION STATION 1D11
1D12 | Level 1 | SPECIMEN COLL. LAB | 10.2108 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-15 11 24 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Laboratory | Historic Preservation Zone 1D | 4.57 | 13.1729 | 43.0838 | 1D12 | SPECIMEN COLL. LAB 1D12
1D13 | Level 1 | INTERACTION STATION | 12.8258 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.432 | 54.5951 | 1D13 | INTERACTION STATION 1D13
1D14 | Level 1 | SPECIMEN TOILET | 4.75347 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 11 14 21 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1D | 4.57 | 8.736 | 19.1241 | 1D14 | SPECIMEN TOILET 1D14
1D15 | Level 1 | WTS & MEAS. ROOM | 5.06769 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 14 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Physical Examination Room | Historic Preservation Zone 1D | 4.57 | 9.0729 | 20.9182 | 1D15 | WTS & MEAS. ROOM 1D15
1D16 | Level 1 | PROVIDER CUBICLES | 67.8336 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-15 11 34 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1D | 4.57 | 36.731 | 300.685 | 1D16 | PROVIDER CUBICLES 1D16
1D17 | Level 1 | JAN. CL. | 2.05671 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-75 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1D | 4.57 | 5.8058 | 7.63765 | 1D17 | JAN. CL. 1D17
1D18 | Level 1 | TOILET | 8.26027 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 11 14 21 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1D | 4.57 | 12.8768 | 33.7603 | 1D18 | TOILET 1D18
1D19 | Level 1 | MDIS VIEW | 5.63662 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-15 11 34 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1D | 4.57 | 9.711 | 23.3793 | 1D19 | MDIS VIEW 1D19
1D20 | Level 1 | APPMTS | 11.7909 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-15 11 34 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1D | 4.57 | 13.74 | 50.0618 | 1D20 | APPMTS 1D20
1D21 | Level 1 | GROUP IS | 19.1917 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 18.161 | 81.906 | 1D21 | GROUP IS 1D21
1D22 | Level 1 | TEAM INTERACTION | 24.237 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-15 11 34 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1D | 4.57 | 20.765 | 106.108 | 1D22 | TEAM INTERACTION 1D22
1D23 | Level 1 | GROUP IS | 19.1868 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 18.161 | 81.8849 | 1D23 | GROUP IS 1D23
1D24 | Level 1 | RECORDS | 11.7777 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-75 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1D | 4.57 | 13.705 | 50.0618 | 1D24 | RECORDS 1D24
1D25 | Level 1 | PROVIDER CUBICLES | 67.8191 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-15 11 34 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1D | 4.57 | 36.627 | 297.963 | 1D25 | PROVIDER CUBICLES 1D25
1D26 | Level 1 | TOILET | 5.04348 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 11 14 21 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1D | 4.57 | 9.172 | 20.1593 | 1D26 | TOILET 1D26
1D27 | Level 1 | ADMIN WORK STATN. | 10.7499 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-15 11 34 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1D | 4.57 | 13.412 | 45.5095 | 1D27 | ADMIN WORK STATN. 1D27
1D28 | Level 1 | INTERACTION STATION | 12.6883 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.364 | 53.9857 | 1D28 | INTERACTION STATION 1D28
1D30 | Level 1 | WTS & MEAS. ROOM | 9.26534 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 14 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Physical Examination Room | Historic Preservation Zone 1D | 4.57 | 12.672 | 38.8224 | 1D30 | WTS & MEAS. ROOM 1D30
1D31 | Level 1 | PEDIATRIC WTS & MSRS | 11.0208 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 14 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Physical Examination Room | Historic Preservation Zone 1D | 4.57 | 13.719 | 46.6988 | 1D31 | PEDIATRIC WTS & MSRS 1D31
1D32 | Level 1 | INTERACTION STATION | 12.7483 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.814 | 54.2672 | 1D32 | INTERACTION STATION 1D32
1D33 | Level 1 | PEDIATRIC WAITING | 12.7423 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-51 31 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Waiting Room | Historic Preservation Zone 1D | 4.57 | 14.432 | 54.3034 | 1D33 | PEDIATRIC WAITING 1D33
1D34 | Level 1 | INTERACTION STATION | 12.8258 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.432 | 54.5951 | 1D34 | INTERACTION STATION 1D34
1D35 | Level 1 | INTERACTION STATION | 12.8258 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.432 | 54.5951 | 1D35 | INTERACTION STATION 1D35
1D36 | Level 1 | INTERACTION STATION | 12.7053 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 14.432 | 54.1702 | 1D36 | INTERACTION STATION 1D36
1D37 | Level 1 | CLEAN U. | 2.35008 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-15 21 11 21 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Clean Room | Historic Preservation Zone 1D | 4.57 | 6.09322 | 9.54417 | 1D37 | CLEAN U. 1D37
1D38 | Level 1 | TRMT ROOM | 23.2605 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Treatment Room | Historic Preservation Zone 1D | 4.57 | 19.59 | 101.447 | 1D38 | TRMT ROOM 1D38
1D39 | Level 1 | JAN. CL. | 2.00067 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-75 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1D | 4.57 | 6.192 | 7.59276 | 1D39 | JAN. CL. 1D39
1D40 | Level 1 | IMMUNIZ'N ROOM | 16.5524 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-41 41 99 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1D | 4.57 | 19.222 | 70.3775 | 1D40 | IMMUNIZ'N ROOM 1D40
1DC5 | Level 1 | CORRIDOR | 6.61219 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-85 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1D | 4.57 | 10.2786 | 27.7547 | 1DC5 | CORRIDOR 1DC5
1DC6 | Level 1 | CORRIDOR | 15.0065 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-85 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1D | 4.57 | 20.1568 | 63.4585 | 1DC6 | CORRIDOR 1DC6
1DC7 | Level 1 | CORRIDOR | 31.9069 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-85 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1D | 4.57 | 37.8435 | 136.3 | 1DC7 | CORRIDOR 1DC7
1DC8 | Level 1 | CORRIDOR | 6.29243 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1D | Fire Alarm Zone 1D | Ventilation Zone 1D | WallCovering | Circulation Zone 1D | FloorCovering | 13-85 11 11 | Lighting Zone 1D | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1D | 4.57 | 10.6091 | 26.8663 | 1DC8 | CORRIDOR 1DC8
1C12 | Level 1 | TOILET | 6.14704 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-41 11 14 21 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1C | 4.57 | 10.0295 | 24.9462 | 1C12 | TOILET 1C12
1C13 | Level 1 | COMM. ROOM | 11.8973 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-15 11 34 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1C | 4.57 | 14.159 | 50.5667 | 1C13 | COMM. ROOM 1C13
1C14 | Level 1 | HIST. / INTV. | 8.18416 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-41 41 99 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1C | 4.57 | 11.509 | 33.4117 | 1C14 | HIST. / INTV. 1C14
1C15 | Level 1 | PES ADMIN. OFFICE | 15.3931 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-15 11 34 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1C | 4.57 | 15.77 | 66.6214 | 1C15 | PES ADMIN. OFFICE 1C15
1C16 | Level 1 | ECG TEST | 10.0079 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-41 41 31 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Scanning/Imaging Room | Historic Preservation Zone 1C | 4.57 | 13.668 | 41.2963 | 1C16 | ECG TEST 1C16
1C17 | Level 1 | CHIEF AERO MED. | 9.94224 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-15 11 34 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1C | 4.57 | 12.691 | 41.1247 | 1C17 | CHIEF AERO MED. 1C17
1C18 | Level 1 | PHYSICAL EXAM | 58.0301 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-41 41 14 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Physical Examination Room | Historic Preservation Zone 1C | 4.57 | 41.077 | 253.075 | 1C18 | PHYSICAL EXAM 1C18
1C19 | Level 1 | AUDIO | 11.6268 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-81 21 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Equipment Room | Historic Preservation Zone 1C | 4.57 | 13.798 | 47.5309 | 1C19 | AUDIO 1C19
1C11 | Level 1 | ELEC. CL. | 0.777824 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-81 21 21 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Electrical Room | Historic Preservation Zone 1C | 4.57 | 4.44 | 2.4667 | 1C11 | ELEC. CL. 1C11
1CS3 | Level 1 | STAIR | 13.9094 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1C | Fire Alarm Zone 1C | Ventilation Zone 1C | WallCovering | Circulation Zone 1C | FloorCovering | 13-85 21 11 | Lighting Zone 1C | LoadCapacity | CeilingCovering | Stairway | Historic Preservation Zone 1C | 4.57 | 18.996 | 58.2892 | 1CS3 | STAIR 1CS3
1E01 | Level 1 | HK EQUIP. STORAGE | 9.72524 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1E | 4.57 | 12.492 | 40.9751 | 1E01 | HK EQUIP. STORAGE 1E01
1E02 | Level 1 | ELEV. EQUIP. | 5.67552 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-81 21 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Equipment Room | Historic Preservation Zone 1E | 4.57 | 9.752 | 23.2443 | 1E02 | ELEV. EQUIP. 1E02
1E03 | Level 1 | JAN. CL. | 3.96995 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1E | 4.57 | 8.652 | 15.8496 | 1E03 | JAN. CL. 1E03
1E04 | Level 1 | HK BREAK ROOM | 9.73544 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-51 11 21 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Break Room | Historic Preservation Zone 1E | 4.57 | 12.492 | 41.0217 | 1E04 | HK BREAK ROOM 1E04
1E05 | Level 1 | CHIEF LOG OFFICE | 9.93876 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-15 11 34 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1E | 4.57 | 12.628 | 41.9124 | 1E05 | CHIEF LOG OFFICE 1E05
1E06 | Level 1 | TECH. WORK STATION | 37.3792 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-15 11 34 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1E | 4.57 | 24.978 | 163.958 | 1E06 | TECH. WORK STATION 1E06
1E07 | Level 1 | CONF. LIBRARY | 11.6309 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-11 21 17 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Conference Room | Historic Preservation Zone 1E | 4.57 | 13.652 | 49.3552 | 1E07 | CONF. LIBRARY 1E07
1E08 | Level 1 | SUPER | 9.86423 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-15 11 34 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1E | 4.57 | 13.058 | 41.5923 | 1E08 | SUPER 1E08
1E09 | Level 1 | W. TOILET | 5.06216 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-41 11 14 21 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1E | 4.57 | 9.206 | 20.3283 | 1E09 | W. TOILET 1E09
1E10 | Level 1 | M. TOILET | 5.06216 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-41 11 14 21 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1E | 4.57 | 9.206 | 20.3283 | 1E10 | M. TOILET 1E10
1E11 | Level 1 | STAFF LOUNGE | 14.5917 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-51 11 21 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Break Room | Historic Preservation Zone 1E | 4.57 | 15.28 | 62.425 | 1E11 | STAFF LOUNGE 1E11
1E12 | Level 1 | ISOLATION TOILET | 5.25186 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-41 11 14 21 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1E | 4.57 | 9.282 | 21.2571 | 1E12 | ISOLATION TOILET 1E12
1E14 | Level 1 | DISASTER STOR. | 22.3553 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1E | 4.57 | 19.889 | 96.6154 | 1E14 | DISASTER STOR. 1E14
1E15 | Level 1 | CENTRAL MECH. RM. | 28.9142 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-81 21 17 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Mechanical Room | Historic Preservation Zone 1E | 4.57 | 24.1165 | 124.109 | 1E15 | CENTRAL MECH. RM. 1E15
1E16 | Level 1 | BMET WORK STATION | 49.5978 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-15 11 34 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1E | 4.57 | 30.9915 | 216.612 | 1E16 | BMET WORK STATION 1E16
1E17 | Level 1 | HAZ. STOR. | 9.78713 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 41 24 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Hazardous Material Storage Space | Historic Preservation Zone 1E | 4.57 | 12.724 | 39.5605 | 1E17 | HAZ. STOR. 1E17
1E18 | Level 1 | BIOMED MAINT. ADMIN. | 15.5543 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-15 11 34 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1E | 4.57 | 15.9435 | 65.6404 | 1E18 | BIOMED MAINT. ADMIN. 1E18
1E19 | Level 1 | ELEC. ROOM | 9.6262 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-81 21 21 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Electrical Room | Historic Preservation Zone 1E | 4.57 | 12.686 | 40.6186 | 1E19 | ELEC. ROOM 1E19
1E20 | Level 1 | TRASH | 8.95436 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 41 14 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Soiled Storage Room Space | Historic Preservation Zone 1E | 4.57 | 12.6045 | 35.998 | 1E20 | TRASH 1E20
1E21 | Level 1 | FLAMABLE STORAGE | 5.66451 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 41 24 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Hazardous Material Storage Space | Historic Preservation Zone 1E | 4.57 | 9.75218 | 22.0609 | 1E21 | FLAMABLE STORAGE 1E21
1E22 | Level 1 | SEC. STORAGE | 6.27284 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1E | 4.57 | 10.424 | 25.7836 | 1E22 | SEC. STORAGE 1E22
1E23 | Level 1 | BEE EQUIP. STORAGE | 8.77894 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-81 21 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Equipment Room | Historic Preservation Zone 1E | 4.57 | 12.981 | 36.8106 | 1E23 | BEE EQUIP. STORAGE 1E23
1E24 | Level 1 | RECEIVING / STORAGE | 118.296 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1E | 4.57 | 48.0138 | 526.098 | 1E24 | RECEIVING / STORAGE 1E24
1E25 | Level 1 | ADP EQUIP SPACE | 11.3734 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1E | 4.57 | 13.9988 | 48.2632 | 1E25 | ADP EQUIP SPACE 1E25
1E26 | Level 1 | WORK ROOM | 19.7143 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-15 11 34 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1E | 4.57 | 18.857 | 83.8395 | 1E26 | WORK ROOM 1E26
1E27 | Level 1 | BENCHSTOCK STORAGE | 9.51258 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1E | 4.57 | 12.337 | 39.0813 | 1E27 | BENCHSTOCK STORAGE 1E27
1E28 | Level 1 | FAC. MGR. OFFICE | 9.73829 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-15 11 34 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1E | 4.57 | 12.614 | 39.4295 | 1E28 | FAC. MGR. OFFICE 1E28
1E29 | Level 1 | HK. SUPV. OFFICE | 11.0301 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-15 11 34 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1E | 4.57 | 13.469 | 45.4695 | 1E29 | HK. SUPV. OFFICE 1E29
1E30 | Level 1 | SOIL. LIN. | 6.87827 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 41 14 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Soiled Storage Room Space | Historic Preservation Zone 1E | 4.57 | 10.7732 | 28.3648 | 1E30 | SOIL. LIN. 1E30
1E33 | Level 1 | ISOLATION INTERACTION STATION | 13.354 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-41 41 99 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1E | 4.57 | 15.028 | 56.9228 | 1E33 | ISOLATION INTERACTION STATION 1E33
1EC1 | Level 1 | CORRIDOR | 54.6636 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-85 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1E | 4.57 | 63.909 | 233.013 | 1EC1 | CORRIDOR 1EC1
1EC2 | Level 1 | CORRIDOR | 7.91371 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-85 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1E | 4.57 | 11.7164 | 33.2359 | 1EC2 | CORRIDOR 1EC2
1EC3 | Level 1 | CORRIDOR | 8.75185 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-85 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1E | 4.57 | 12.6304 | 36.8072 | 1EC3 | CORRIDOR 1EC3
1EC4 | Level 1 | CORRIDOR | 9.30567 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-85 11 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1E | 4.57 | 12.6514 | 38.6777 | 1EC4 | CORRIDOR 1EC4
1BC1 | Level 1 | CORRIDOR | 5.69274 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-85 11 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1B | 4.57 | 9.876 | 23.2878 | 1BC1 | CORRIDOR 1BC1
1BC2 | Level 1 | CORRIDOR | 29.4368 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-85 11 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1B | 4.57 | 36.1589 | 124.84 | 1BC2 | CORRIDOR 1BC2
1BC3 | Level 1 | CORRIDOR | 13.4396 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-85 11 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1B | 4.57 | 18.0333 | 56.7818 | 1BC3 | CORRIDOR 1BC3
1BC4 | Level 1 | CORRIDOR | 44.3648 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-85 11 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 1B | 4.57 | 44.8858 | 190.667 | 1BC4 | CORRIDOR 1BC4
1B01 | Level 1 | RECEPTION | 9.47555 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-11 11 31 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Reception Space | Historic Preservation Zone 1B | 4.57 | 12.664 | 40.2539 | 1B01 | RECEPTION 1B01
1B02 | Level 1 | SPECIMEN TOILET | 5.54853 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-41 11 14 21 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1B | 4.57 | 10.2769 | 22.4111 | 1B02 | SPECIMEN TOILET 1B02
1B03 | Level 1 | BLOOD DRAW | 9.68098 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-41 41 99 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1B | 4.57 | 12.732 | 40.7049 | 1B03 | BLOOD DRAW 1B03
1B04 | Level 1 | LAB | 53.5882 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-15 11 24 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Laboratory | Historic Preservation Zone 1B | 4.57 | 36.9479 | 233.961 | 1B04 | LAB 1B04
1B05 | Level 1 | PAT. / STAFF TOILET | 4.78883 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-41 11 14 21 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1B | 4.57 | 8.832 | 19.2728 | 1B05 | PAT. / STAFF TOILET 1B05
1B06 | Level 1 | LAB OFFICE | 10.4755 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-15 11 34 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1B | 4.57 | 13.1609 | 42.7346 | 1B06 | LAB OFFICE 1B06
1B07 | Level 1 | DRESS | 4.42138 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-41 11 41 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Dressing Room | Historic Preservation Zone 1B | 4.57 | 8.704 | 17.8098 | 1B07 | DRESS 1B07
1B08 | Level 1 | CENT. STO. | 9.76711 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-75 11 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1B | 4.57 | 12.796 | 40.8399 | 1B08 | CENT. STO. 1B08
1B09 | Level 1 | DRESS | 4.64607 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-41 11 41 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Dressing Room | Historic Preservation Zone 1B | 4.57 | 8.64805 | 18.8525 | 1B09 | DRESS 1B09
1B10 | Level 1 | STAFF LOUNGE | 10.2834 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-51 11 21 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Break Room | Historic Preservation Zone 1B | 4.57 | 13.649 | 42.9879 | 1B10 | STAFF LOUNGE 1B10
1B11 | Level 1 | STAFF TOILET | 4.99399 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-41 11 14 21 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 1B | 4.57 | 8.996 | 20.1557 | 1B11 | STAFF TOILET 1B11
1B12 | Level 1 | CLEAN SUP. & EQUIP. | 3.90136 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-75 11 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1B | 4.57 | 8.51705 | 15.0909 | 1B12 | CLEAN SUP. & EQUIP. 1B12
1B13 | Level 1 | RECEPTION | 22.5898 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-11 11 31 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Reception Space | Historic Preservation Zone 1B | 4.57 | 21.5613 | 98.0739 | 1B13 | RECEPTION 1B13
1B14 | Level 1 | SOIL. UTL. | 4.03581 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-75 41 14 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Soiled Storage Room Space | Historic Preservation Zone 1B | 4.57 | 8.609 | 15.6642 | 1B14 | SOIL. UTL. 1B14
1B15 | Level 1 | FILM VIEW | 5.83705 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-41 41 31 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Scanning/Imaging Room | Historic Preservation Zone 1B | 4.57 | 9.664 | 24.0074 | 1B15 | FILM VIEW 1B15
1B16 | Level 1 | JAN. CL. | 4.03581 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-75 11 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1B | 4.57 | 8.609 | 15.6642 | 1B16 | JAN. CL. 1B16
1B17 | Level 1 | TECH. WORK ROOM | 24.0437 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-15 11 34 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1B | 4.57 | 20.0581 | 105.278 | 1B17 | TECH. WORK ROOM 1B17
1B19 | Level 1 | RADIOGRAPHIC ROOM | 29.9132 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-41 41 99 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 1B | 4.57 | 28.5508 | 129.023 | 1B19 | RADIOGRAPHIC ROOM 1B19
1B21 | Level 1 | COMM. ROOM | 9.80232 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-15 11 34 11 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 1B | 4.57 | 13.012 | 41.1801 | 1B21 | COMM. ROOM 1B21
1B23 | Level 1 | ELEC. ROOM | 9.88297 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-81 21 21 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Electrical Room | Historic Preservation Zone 1B | 4.57 | 13.0801 | 41.5293 | 1B23 | ELEC. ROOM 1B23
1ES2 | Level 1 | STAIR | 16.0319 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-85 21 11 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Stairway | Historic Preservation Zone 1E | 4.57 | 18.161 | 67.7732 | 1ES2 | STAIR 1ES2
1A16 | Level 1 | PHARM. DISP. | 67.5491 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-75 11 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 1A | 4.57 | 42.597 | 298.077 | 1A16 | PHARM. DISP. 1A16
1AS1 | Level 1 | STAIR | 14.0577 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1A | Fire Alarm Zone 1A | Ventilation Zone 1A | WallCovering | Circulation Zone 1A | FloorCovering | 13-85 21 11 | Lighting Zone 1A | LoadCapacity | CeilingCovering | Stairway | Historic Preservation Zone 1A | 4.57 | 15.646 | 62.0448 | 1AS1 | STAIR 1AS1
1E15-A | Level 1 | GAS STORAGE | 2.28945 | 0 | Level: Level 1 | 0 | Level: Level 2 | Occupancy Zone 1E | Fire Alarm Zone 1E | Ventilation Zone 1E | WallCovering | Circulation Zone 1E | FloorCovering | 13-75 41 24 | Lighting Zone 1E | LoadCapacity | CeilingCovering | Hazardous Material Storage Space | Historic Preservation Zone 1E | 4.57 | 7.3006 | 7.57512 | 1E15-A | GAS STORAGE 1E15-A
E1 | Level 1 | ELEVATOR | 4.35577 | 0 | Level: Level 1 | 0 | Level: Roof - Main | Occupancy Zone 1B | Fire Alarm Zone 1B | Ventilation Zone 1B | WallCovering | Circulation Zone 1B | FloorCovering | 13-81 21 31 | Lighting Zone 1B | LoadCapacity | CeilingCovering | Elevator Shaft | Historic Preservation Zone 1B | 9.25 | 8.4154 | 36.1313 | E1 | ELEVATOR E1
2AC1 | Level 2 | CORRIDOR | 22.0952 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-85 11 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2A | 4.68 | 22.5409 | 100.777 | 2AC1 | CORRIDOR 2AC1
2AC2 | Level 2 | CORRIDOR | 15.0174 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-85 11 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2A | 4.68 | 21.167 | 65.173 | 2AC2 | CORRIDOR 2AC2
2AC3 | Level 2 | CORRIDOR | 27.093 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-85 11 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2A | 4.68 | 33.5372 | 120.308 | 2AC3 | CORRIDOR 2AC3
