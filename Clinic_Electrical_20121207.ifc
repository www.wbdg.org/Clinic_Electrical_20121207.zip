Properties of the parts of a building model (IFC2X3), part 2 of 7

# IfcSpace (266)
Name | In | LongName = Name | GSA BIM Area (m2) = Area (m2) | Base Offset (m) | Level | Limit Offset (m) | Upper Limit | OccupancyZoneName | FireAlarmZoneName | VentilationZoneName | Other, WallCovering = Pset_SpaceCommon, WallCovering | CirculationZoneName | Other, FloorCovering = Pset_SpaceCommon, FloorCovering | Category Code | LightingZoneName | LoadCapacity | Other, CeilingCovering = Pset_SpaceCommon, CeilingCovering | Category Description = OmniClass Table 13 Category | HistoricPreservationZoneName | Unbounded Height (m) | Perimeter (m) | Volume (m3) | Number | Reference
2AC4 | Level 2 | CORRIDOR | 14.3235 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-85 11 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2A | 4.68 | 19.474 | 62.7632 | 2AC4 | CORRIDOR 2AC4
2AC5 | Level 2 | CORRIDOR | 9.10214 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-85 11 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2A | 4.68 | 13.0124 | 39.2217 | 2AC5 | CORRIDOR 2AC5
2AS1 | Level 2 | STAIR | 14.4483 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-85 21 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Stairway | Historic Preservation Zone 2A | 4.68 | 15.3236 | 63.8539 | 2AS1 | STAIR 2AS1
2A01 | Level 2 | LIBRARY / CONF. ROOM | 26.331 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-11 21 17 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Conference Room | Historic Preservation Zone 2A | 4.68 | 21.7164 | 116.652 | 2A01 | LIBRARY / CONF. ROOM 2A01
2A02 | Level 2 | SUPER OFFICE | 10.8708 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-15 11 34 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2A | 4.68 | 14.101 | 46.9093 | 2A02 | SUPER OFFICE 2A02
2A03 | Level 2 | SEC. OFFICE | 16.0095 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-15 11 34 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2A | 4.68 | 16.097 | 69.1645 | 2A03 | SEC. OFFICE 2A03
2A04 | Level 2 | DENTAL SURGEON OFFICE | 16.0139 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-15 11 34 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2A | 4.68 | 16.099 | 69.882 | 2A04 | DENTAL SURGEON OFFICE 2A04
2A05 | Level 2 | OH DTR #1 | 11.3331 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-41 41 99 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2A | 4.68 | 13.8601 | 49.1569 | 2A05 | OH DTR #1 2A05
2A06 | Level 2 | OH DTR #2 | 12.0879 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-41 41 99 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2A | 4.68 | 13.9081 | 51.7661 | 2A06 | OH DTR #2 2A06
2A07 | Level 2 | OH DTR #3 | 12.0034 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-41 41 99 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2A | 4.68 | 13.5693 | 51.4118 | 2A07 | OH DTR #3 2A07
2A08 | Level 2 | GEN. DENT. DTR #4 | 11.7457 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-41 41 99 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2A | 4.68 | 13.5693 | 50.5656 | 2A08 | GEN. DENT. DTR #4 2A08
2A09 | Level 2 | GEN. DENT. DTR #5 | 11.3064 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-41 41 99 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2A | 4.68 | 13.5013 | 48.9247 | 2A09 | GEN. DENT. DTR #5 2A09
2A10 | Level 2 | DENTAL WAITING | 7.85686 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-51 31 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Waiting Room | Historic Preservation Zone 2A | 4.68 | 10.8741 | 34.187 | 2A10 | DENTAL WAITING 2A10
2A11 | Level 2 | DENTAL WAITING | 33.4127 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-51 31 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Waiting Room | Historic Preservation Zone 2A | 4.68 | 28.9809 | 149.03 | 2A11 | DENTAL WAITING 2A11
2A12 | Level 2 | X-RAY | 11.2172 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-41 41 31 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Scanning/Imaging Room | Historic Preservation Zone 2A | 4.68 | 14.3622 | 48.4044 | 2A12 | X-RAY 2A12
2A13 | Level 2 | DEVELOPING | 7.5623 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-41 41 31 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Scanning/Imaging Room | Historic Preservation Zone 2A | 4.68 | 11.778 | 32.2219 | 2A13 | DEVELOPING 2A13
2A12-A | Level 2 | X-RAY ALCOVE | 2.28699 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-41 41 31 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Scanning/Imaging Room | Historic Preservation Zone 2A | 4.68 | 5.62774 | 9.33931 | 2A12-A | X-RAY ALCOVE 2A12-A
2A14 | Level 2 | ADMIN | 32.726 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-15 11 34 11 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2A | 4.68 | 24.5217 | 147.286 | 2A14 | ADMIN 2A14
2C01 | Level 2 | DTR SUPPORT | 8.72505 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-15 11 34 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2C | 4.68 | 11.958 | 37.9803 | 2C01 | DTR SUPPORT 2C01
2C02 | Level 2 | GEN. DENT. DTR #6 | 12.0034 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 41 99 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2C | 4.68 | 13.8601 | 51.3922 | 2C02 | GEN. DENT. DTR #6 2C02
2C03 | Level 2 | CONSULT. | 33.4679 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 41 99 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2C | 4.68 | 28.401 | 149.464 | 2C03 | CONSULT. 2C03
2C04 | Level 2 | GEN. DENT. DTR #7 | 11.1795 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 41 99 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2C | 4.68 | 13.8601 | 48.3108 | 2C04 | GEN. DENT. DTR #7 2C04
2C05 | Level 2 | JAN. CL. | 3.69253 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-75 11 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 2C | 4.68 | 8.264 | 15.1496 | 2C05 | JAN. CL. 2C05
2C06 | Level 2 | GEN. DENT. DTR #8 | 12.0034 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 41 99 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2C | 4.68 | 13.8601 | 51.1267 | 2C06 | GEN. DENT. DTR #8 2C06
2C07 | Level 2 | M. STAFF TOILET | 18.2427 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 11 14 21 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 2C | 4.68 | 27.3188 | 77.0474 | 2C07 | M. STAFF TOILET 2C07
2C08 | Level 2 | W. STAFF TOILET | 15.7322 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 11 14 21 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 2C | 4.68 | 21.984 | 66.7915 | 2C08 | W. STAFF TOILET 2C08
2C09 | Level 2 | GEN. DENT. DTR #9 | 11.3638 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 41 99 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2C | 4.68 | 13.8601 | 48.9519 | 2C09 | GEN. DENT. DTR #9 2C09
2C10 | Level 2 | DIPC DECON | 11.0309 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 41 99 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2C | 4.68 | 13.492 | 47.9695 | 2C10 | DIPC DECON 2C10
2C11 | Level 2 | HK | 5.0922 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 41 99 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2C | 4.68 | 9.49 | 21.3982 | 2C11 | HK 2C11
2C12 | Level 2 | DIPC CLEAN | 14.3677 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 41 99 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2C | 4.68 | 18.173 | 62.0415 | 2C12 | DIPC CLEAN 2C12
2C13 | Level 2 | TRASH | 5.53953 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-75 41 14 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Soiled Storage Room Space | Historic Preservation Zone 2C | 4.68 | 10.182 | 23.3475 | 2C13 | TRASH 2C13
2C14 | Level 2 | GEN. DENT. DTR #10 | 12.0102 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 41 99 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Other Healing Spaces | Historic Preservation Zone 2C | 4.68 | 13.997 | 51.6858 | 2C14 | GEN. DENT. DTR #10 2C14
2C15 | Level 2 | COMM. ROOM | 9.58001 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-15 11 34 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2C | 4.68 | 12.53 | 41.2928 | 2C15 | COMM. ROOM 2C15
2C16 | Level 2 | CERAMIC LAB | 11.155 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-15 11 24 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Laboratory | Historic Preservation Zone 2C | 4.68 | 14.018 | 47.4451 | 2C16 | CERAMIC LAB 2C16
2C17 | Level 2 | PROSTH. LAB | 30.5599 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-15 11 24 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Laboratory | Historic Preservation Zone 2C | 4.68 | 25.496 | 133.781 | 2C17 | PROSTH. LAB 2C17
2C18 | Level 2 | ELECTRICAL | 9.84 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-81 21 21 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Electrical Room | Historic Preservation Zone 2C | 4.68 | 12.56 | 42.4788 | 2C18 | ELECTRICAL 2C18
2C19 | Level 2 | CENTRAL ISSUE | 21.0386 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-75 11 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 2C | 4.68 | 19.886 | 92.6739 | 2C19 | CENTRAL ISSUE 2C19
2C22 | Level 2 | LOUNGE | 11.1646 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-51 11 21 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Break Room | Historic Preservation Zone 2C | 4.68 | 13.8043 | 48.3167 | 2C22 | LOUNGE 2C22
2C23 | Level 2 | M. TOILET | 8.65877 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 11 14 21 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 2C | 4.68 | 13.2267 | 35.8677 | 2C23 | M. TOILET 2C23
2C24 | Level 2 | W. TOILET | 9.22003 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-41 11 14 21 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 2C | 4.68 | 12.1502 | 39.7625 | 2C24 | W. TOILET 2C24
2CC1 | Level 2 | CORRIDOR | 18.813 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-85 11 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2C | 4.68 | 23.5826 | 81.5171 | 2CC1 | CORRIDOR 2CC1
2CC3 | Level 2 | CORRIDOR | 17.2506 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-85 11 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2C | 4.68 | 22.3132 | 75.2743 | 2CC3 | CORRIDOR 2CC3
2CC4 | Level 2 | CORRIDOR | 10.846 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-85 11 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2C | 4.68 | 14.568 | 47.0298 | 2CC4 | CORRIDOR 2CC4
2CC2 | Level 2 | CORRIDOR | 13.3735 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-85 11 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2C | 4.68 | 18.1884 | 58.1257 | 2CC2 | CORRIDOR 2CC2
2D01 | Level 2 | PARTS STORAGE | 8.92422 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-75 11 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 2D | 4.68 | 12.352 | 38.6107 | 2D01 | PARTS STORAGE 2D01
2D02 | Level 2 | DATA / ARCHIVE STORAGE | 9.92268 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-75 11 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 2D | 4.68 | 12.868 | 43.176 | 2D02 | DATA / ARCHIVE STORAGE 2D02
2D03 | Level 2 | DIR. INFO MGR | 9.4116 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 12.5175 | 40.827 | 2D03 | DIR. INFO MGR 2D03
2D04 | Level 2 | SYS. ANALYST | 20.7007 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 19.9515 | 90.9847 | 2D04 | SYS. ANALYST 2D04
2D05 | Level 2 | MAIN MECHANICAL ROOM | 231.114 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-81 21 17 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Mechanical Room | Historic Preservation Zone 2D | 4.68 | 65.482 | 1057.88 | 2D05 | MAIN MECHANICAL ROOM 2D05
2D06 | Level 2 | COPY / FILE | 11.9777 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 27 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Copy Room | Historic Preservation Zone 2D | 4.68 | 14.02 | 52.2063 | 2D06 | COPY / FILE 2D06
2D07 | Level 2 | SUPER | 9.21541 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 12.135 | 39.7607 | 2D07 | SUPER 2D07
2D08 | Level 2 | QA / HRD DIRECTOR | 8.98396 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 12.282 | 38.7648 | 2D08 | QA / HRD DIRECTOR 2D08
2D09 | Level 2 | ADMIN OFFICE | 14.3932 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 15.445 | 62.3152 | 2D09 | ADMIN OFFICE 2D09
2D10 | Level 2 | SEC. WAIT | 16.632 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-51 31 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Waiting Room | Historic Preservation Zone 2D | 4.68 | 17.017 | 73.3064 | 2D10 | SEC. WAIT 2D10
2D11 | Level 2 | CMDR OFFICE | 15.8554 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 16.0179 | 67.7917 | 2D11 | CMDR OFFICE 2D11
2D12 | Level 2 | VEST. | 2.79678 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-85 31 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Entry Vestibule | Historic Preservation Zone 2D | 4.68 | 6.5021 | 10.89 | 2D12 | VEST. 2D12
2D13 | Level 2 | TOILET | 4.74366 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-41 11 14 21 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 2D | 4.68 | 9.012 | 19.5769 | 2D13 | TOILET 2D13
2D14 | Level 2 | OPS SQUAD CMDR | 13.6001 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 15.4428 | 59.5061 | 2D14 | OPS SQUAD CMDR 2D14
2D15 | Level 2 | 1ST SGT | 10.8297 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 13.588 | 46.4509 | 2D15 | 1ST SGT 2D15
2D16 | Level 2 | RMO DIR. | 9.75054 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 13.1899 | 41.9669 | 2D16 | RMO DIR. 2D16
2D17 | Level 2 | CREDENTIALS MGR | 9.64538 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 12.7579 | 40.7054 | 2D17 | CREDENTIALS MGR 2D17
2D18 | Level 2 | TECH. OFFICE | 84.8029 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 45.572 | 384.177 | 2D18 | TECH. OFFICE 2D18
2D19 | Level 2 | READINESS NCOIC OFFICE | 10.9078 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 13.5279 | 46.6431 | 2D19 | READINESS NCOIC OFFICE 2D19
2D20 | Level 2 | CONF. ROOM | 30.712 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-11 21 17 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Conference Room | Historic Preservation Zone 2D | 4.68 | 22.3024 | 137.383 | 2D20 | CONF. ROOM 2D20
2D04-A | Level 2 | COMPUTER ROOM | 33.5478 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-15 11 34 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2D | 4.68 | 23.6075 | 150.137 | 2D04-A | COMPUTER ROOM 2D04-A
2DC1 | Level 2 | CORRIDOR | 21.5518 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-85 11 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2D | 4.68 | 26.2857 | 94.273 | 2DC1 | CORRIDOR 2DC1
2DC2 | Level 2 | CORRIDOR | 30.1132 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-85 11 11 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2D | 4.68 | 36.3978 | 132.799 | 2DC2 | CORRIDOR 2DC2
2BC1 | Level 2 | CORRIDOR | 12.8241 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-85 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2B | 4.68 | 15.4512 | 56.8647 | 2BC1 | CORRIDOR 2BC1
2BC2 | Level 2 | CORRIDOR | 29.512 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-85 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2B | 4.68 | 32.1099 | 129.127 | 2BC2 | CORRIDOR 2BC2
2BC3 | Level 2 | CORRIDOR | 26.8 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-85 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2B | 4.68 | 32.8839 | 116.64 | 2BC3 | CORRIDOR 2BC3
2BC4 | Level 2 | CORRIDOR | 12.4825 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-85 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2B | 4.68 | 16.6806 | 54.0397 | 2BC4 | CORRIDOR 2BC4
2BC5 | Level 2 | CORRIDOR | 22.7376 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-85 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2B | 4.68 | 29.2148 | 98.007 | 2BC5 | CORRIDOR 2BC5
2BC6 | Level 2 | CORRIDOR | 8.57508 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-85 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2B | 4.68 | 12.7244 | 37.2922 | 2BC6 | CORRIDOR 2BC6
2B01 | Level 2 | OFFICE | 9.36297 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 12.861 | 40.2377 | 2B01 | OFFICE 2B01
2B2 | Level 2 | JAN. CL. | 2.20008 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-75 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 2B | 4.68 | 5.938 | 8.8583 | 2B2 | JAN. CL. 2B2
2B3 | Level 2 | CONF. / GROUP THERAPY | 19.2831 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-11 21 17 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Conference Room | Historic Preservation Zone 2B | 4.68 | 19.7196 | 83.7647 | 2B3 | CONF. / GROUP THERAPY 2B3
2B4 | Level 2 | PSYCH TEST | 9.8406 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 12.61 | 42.9119 | 2B4 | PSYCH TEST 2B4
2B5 | Level 2 | W. TOILET | 4.73083 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-41 11 14 21 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 2B | 4.68 | 8.976 | 19.3327 | 2B5 | W. TOILET 2B5
2B6 | Level 2 | STAFF TOILET | 5.65351 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-41 11 14 21 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 2B | 4.68 | 9.636 | 23.4593 | 2B6 | STAFF TOILET 2B6
2B7 | Level 2 | TECH OFFICE | 9.9308 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 12.685 | 43.2279 | 2B7 | TECH OFFICE 2B7
2B8 | Level 2 | OFFICE / EXAM | 12.6405 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 14.84 | 54.9235 | 2B8 | OFFICE / EXAM 2B8
2B9 | Level 2 | TECH OFFICE | 9.94 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 12.68 | 42.9119 | 2B9 | TECH OFFICE 2B9
2B10 | Level 2 | RECEPTION | 15.1738 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-11 11 31 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Reception Space | Historic Preservation Zone 2B | 4.68 | 16.625 | 66.3692 | 2B10 | RECEPTION 2B10
2B11 | Level 2 | WAITING | 10.1069 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-51 31 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Waiting Room | Historic Preservation Zone 2B | 4.68 | 12.908 | 44.5767 | 2B11 | WAITING 2B11
2B12 | Level 2 | COMM. ROOM | 9.92484 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 13.085 | 42.7387 | 2B12 | COMM. ROOM 2B12
2B13 | Level 2 | ELECTRICAL | 9.68587 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-81 21 21 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Electrical Room | Historic Preservation Zone 2B | 4.68 | 12.977 | 41.6723 | 2B13 | ELECTRICAL 2B13
2B14 | Level 2 | RECS / FORMS STORAGE | 10.5466 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-75 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 2B | 4.68 | 13.604 | 45.661 | 2B14 | RECS / FORMS STORAGE 2B14
2B15 | Level 2 | WAIT / ERGOM | 9.11758 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-51 31 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Waiting Room | Historic Preservation Zone 2B | 4.68 | 12.24 | 39.1907 | 2B15 | WAIT / ERGOM 2B15
2B16 | Level 2 | PH TECH | 9.51632 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 12.357 | 39.9755 | 2B16 | PH TECH 2B16
2B17 | Level 2 | CL. UTL. / KITCHENET | 8.99668 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-11 19 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Kitchen | Historic Preservation Zone 2B | 4.68 | 12.172 | 38.6446 | 2B17 | CL. UTL. / KITCHENET 2B17
2B18 | Level 2 | PH TECH | 9.52429 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 13.8569 | 40.5288 | 2B18 | PH TECH 2B18
2B19 | Level 2 | OFFICE | 8.87578 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 12.104 | 38.0985 | 2B19 | OFFICE 2B19
2B20 | Level 2 | JAN. CL. | 3.23618 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-75 11 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Storage Room | Historic Preservation Zone 2B | 4.68 | 7.53312 | 13.2284 | 2B20 | JAN. CL. 2B20
2B21 | Level 2 | PH SUPER | 9.25086 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 12.5366 | 39.4905 | 2B21 | PH SUPER 2B21
2B22 | Level 2 | M. TOILET | 5.16718 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-41 11 14 21 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Restroom | Historic Preservation Zone 2B | 4.68 | 9.11944 | 20.7808 | 2B22 | M. TOILET 2B22
2B23 | Level 2 | BEE TECH | 10.7975 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 13.226 | 46.3948 | 2B23 | BEE TECH 2B23
2B24 | Level 2 | BEE TECH | 9.77601 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-15 11 34 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Office | Historic Preservation Zone 2B | 4.68 | 12.67 | 41.2986 | 2B24 | BEE TECH 2B24
2B25 | Level 2 | SOIL. UTL. / TRASH | 7.46369 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-75 41 14 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Soiled Storage Room Space | Historic Preservation Zone 2B | 4.68 | 13.21 | 31.4753 | 2B25 | SOIL. UTL. / TRASH 2B25
2BS2 | Level 2 | STAIR | 15.4516 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2B | Fire Alarm Zone 2B | Ventilation Zone 2B | WallCovering | Circulation Zone 2B | FloorCovering | 13-85 21 11 | Lighting Zone 2B | LoadCapacity | CeilingCovering | Stairway | Historic Preservation Zone 2B | 4.68 | 17.332 | 67.3562 | 2BS2 | STAIR 2BS2
2CS3 | Level 2 | STAIR | 15.2659 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-85 21 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Stairway | Historic Preservation Zone 2C | 4.68 | 17.368 | 66.4769 | 2CS3 | STAIR 2CS3
2AC1-A | Level 2 | OPEN TO BELOW | 67.4123 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-85 31 99 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Other Transitional Circulation Spaces | Historic Preservation Zone 2A | 4.68 | 37.7705 | 306.477 | 2AC1-A | OPEN TO BELOW 2AC1-A
2AC1-B | Level 2 | OPEN TO BELOW | 75.807 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2A | Fire Alarm Zone 2A | Ventilation Zone 2A | WallCovering | Circulation Zone 2A | FloorCovering | 13-85 31 99 | Lighting Zone 2A | LoadCapacity | CeilingCovering | Other Transitional Circulation Spaces | Historic Preservation Zone 2A | 4.68 | 35.407 | 348.032 | 2AC1-B | OPEN TO BELOW 2AC1-B
2CC5 | Level 2 | CORRIDOR | 8.1288 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2C | Fire Alarm Zone 2C | Ventilation Zone 2C | WallCovering | Circulation Zone 2C | FloorCovering | 13-85 11 11 | Lighting Zone 2C | LoadCapacity | CeilingCovering | Corridor | Historic Preservation Zone 2C | 4.68 | 12.632 | 34.7149 | 2CC5 | CORRIDOR 2CC5
2D21 | Level 2 | LIBRARY / CLASSROOM | 27.3034 | 0 | Level: Level 2 | 0 | Level: Roof - Main | Occupancy Zone 2D | Fire Alarm Zone 2D | Ventilation Zone 2D | WallCovering | Circulation Zone 2D | FloorCovering | 13-11 11 17 | Lighting Zone 2D | LoadCapacity | CeilingCovering | Classroom | Historic Preservation Zone 2D | 4.68 | 21.2805 | 123.751 | 2D21 | LIBRARY / CLASSROOM 2D21
2R02 | Level 2 | ROOF | 589.756 | 0 | Level: Level 2 | 4 | Level: Level 2 | Occupancy Zone 2R | Fire Alarm Zone 2R | Ventilation Zone 2R |  | Circulation Zone 2R |  | 13-81 11 99 | Lighting Zone 2R |  |  | Other General Facility Service Spaces | Historic Preservation Zone 2R | 4 | 194.084 | 2314.97 | 2R02 | ROOF 2R02
2R01 | Level 2 | ROOF | 52.8728 | 0 | Level: Level 2 | 4 | Level: Level 2 | Occupancy Zone 2R | Fire Alarm Zone 2R | Ventilation Zone 2R |  | Circulation Zone 2R |  | 13-81 11 99 | Lighting Zone 2R |  |  | Other General Facility Service Spaces | Historic Preservation Zone 2R | 4 | 29.706 | 203.631 | 2R01 | ROOF 2R01
3R01 | Roof - Main | ROOF | 1568.12 | 0 | Level: Roof - Main | 4 | Level: Roof - Main | Occupancy Zone 3R | Fire Alarm Zone 3R | Ventilation Zone 3R |  | Circulation Zone 3R |  | 13-81 11 99 | Lighting Zone 3R |  |  | Other General Facility Service Spaces | Historic Preservation Zone 3R | 4 | 319.667 | 6230.74 | 3R01 | ROOF 3R01
3R02 | Roof - Main | ROOF | 7.6871 | -1.2 | Level: Roof - Main | 4 | Level: Roof - Main | Occupancy Zone 3R | Fire Alarm Zone 3R | Ventilation Zone 3R |  | Circulation Zone 3R |  | 13-81 11 99 | Lighting Zone 3R |  |  | Other General Facility Service Spaces | Historic Preservation Zone 3R | 5.2 | 17.3688 | 39.3279 | 3R02 | ROOF 3R02
3R04 | Roof - Main | ROOF | 2.83973 | -1.2 | Level: Roof - Main | 4 | Level: Roof - Main | Occupancy Zone 3R | Fire Alarm Zone 3R | Ventilation Zone 3R |  | Circulation Zone 3R |  | 13-81 11 99 | Lighting Zone 3R |  |  | Other General Facility Service Spaces | Historic Preservation Zone 3R | 5.2 | 7.39825 | 14.1218 | 3R04 | ROOF 3R04
3R03 | Roof - Main | ROOF | 58.0215 | -2.48688 | Level: Roof - Main | 4 | Level: Roof - Main | Occupancy Zone 3R | Fire Alarm Zone 3R | Ventilation Zone 3R |  | Circulation Zone 3R |  | 13-81 11 99 | Lighting Zone 3R |  |  | Other General Facility Service Spaces | Historic Preservation Zone 3R | 6.48688 | 30.2887 | 374.943 | 3R03 | ROOF 3R03

# IfcBuildingElementProxy: 2000 lbs, M_Elevator-Hydraulic:2000 lbs:2000 lbs:1186968
In: E1
Material: Metal - Steel
Identity Data - OmniClass Number: 23.50.05.11; OmniClass Title: Elevators; Manufacturer: N/A; Mark: 964
Other - Shape: N/A; Width: 2.2352 m; NominalHeight: 0; NominalWidth: 0; ModelLabel: N/A; Size: 0; Cab Width: 1.8288 m; NominalFrequencyRange: 0; Cab Location: 3.6576 m; NominalLength: 0; NumberOfPoles: 0; Cab Height: 2.286 m; WarrantyGuarantorLabor: N/A; Depth: 1.7526 m; PowerFactor: 0; ReplacementCost: N/A; WarrantyDescription: N/A; HasProtectiveEarth: TRUE; AssetAccountingType: FIXED; ProductionYear: N/A; ConductorFunction: L1; Door Opening: 0.9144 m; IP_Code: 0; Constituents: N/A; Grade: N/A; WarrantyDurationLabor: N/A; Cab Depth: 1.524 m; SustainabilityPerformance: N/A; RatedVoltage: 0; Features: N/A; Material: N/A; ExpectedLife: N/A; RatedCurrent: 0; ModelReference: N/A; WarrantyGuarantorParts: N/A; CodePerformance: N/A; IsPluggableOutlet: TRUE; WarrantyDurationParts: N/A; Pit Depth: 1.2192 m; AccessibilityPerformance: N/A; BarCode: N/A; AssetIdentifier: N/A; SerialNumber: N/A; InstallationDate: N/A; Height: 10.9728 m; TagNumber: N/A; WarrantyStartDate: N/A
Phasing - Phase Created: New Construction
Constraints - Offset: 0 m; Host: Level : Level 1; Moves With Nearby Elements: no; Level: Level: Level 1
Pset_BuildingElementProxyCommon - Reference: 2000 lbs

# IfcBuildingElementProxy: 225 A (28)
Constraints - Default Elevation: 1.2 m; Elevation: 1.2 m; Offset: 0 m
Dimensions - Width: 0.508 m; 12 Circuit Height: 0.8128 m; 30 Circuit Height: 0.8128 m; 42 Circuit Height: 1.0414 m; Depth: 0.1461 m; 24 Circuit Height: 0.8128 m
Electrical - Load Classification: Other
Identity Data - Manufacturer: N/A; OmniClass Title: Distribution Boards and Control Panels; OmniClass Number: 23.80.30.11.17
Other - PowerFactor: 0; NominalFrequencyRange: 0; IP_Code: 0; SustainabilityPerformance: N/A; Grade: N/A; NumberOfPoles: 0; Material: N/A; NominalLength: 0; AssetAccountingType: FIXED; RatedCurrent: 0; ModelLabel: N/A; WarrantyGuarantorParts: N/A; RatedVoltage: 0; ModelReference: N/A; WarrantyDurationLabor: N/A; NominalHeight: 0; ReplacementCost: N/A; Features: N/A; NominalWidth: 0; AccessibilityPerformance: N/A; ProductionYear: N/A; CodePerformance: N/A; Constituents: N/A; Shape: N/A; ConductorFunction: L1; HasProtectiveEarth: TRUE; ExpectedLife: N/A; WarrantyDurationParts: N/A; Size: 0; WarrantyGuarantorLabor: N/A; WarrantyDescription: N/A; IsSkilledOperator: TRUE; BarCode: N/A; TagNumber: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; SerialNumber: N/A; AssetIdentifier: N/A
Electrical - Circuiting - Mains: 100; Number of Phases: 3; Number of Wires: 4; Distribution System: Distribution System: 120/208 Wye; Electrical Data: 208 V/3-0 VA
Phasing - Phase Created: New Construction
General - Enclosure: Type 1; Mounting: Recessed
Pset_BuildingElementProxyCommon - Reference: 225 A
Name (M_Lighting and Appliance Panelboard - 208V MLO:225 A:...) | In | Total Demand Factor | Total Connected Current | Apparent Load Phase B | Current Phase B | Current Phase C | Current Phase A | Total Connected | Total Estimated Demand Current | Apparent Load Phase C | Total Estimated Demand | Apparent Load Phase A | Max #1 Pole Breakers | Supply From | Schedule Level | Host | Panel Name | Location | Mark | Height (m)
N21E2:858534 | 1E19 | 0.735405 | 58.9563 | 65875.1 | 51 | 57.9231 | 69.9231 | 228625 | 43.3568 | 73625.1 | 168132 | 89125.2 | 36 | F21E | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | N21E2 | ELEC. ROOM 1E19-M | 1 | 1.0414 | Electrical - Loads - Receptacle Connected: 228625; Receptacle Estimated Demand: 168132; Receptacle Demand Factor: 0.735405; Receptacle Estimated Demand Current: 43.3568; Receptacle Connected Current: 58.9563
N21E1:858660 | 1E19 | 0.808642 | 44.9667 | 52312.6 | 40.5 | 52.7308 | 42.2308 | 174375 | 36.362 | 67812.6 | 141007 | 54250.1 | 36 | F21E | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | N21E1 | ELEC. ROOM 1E19-M | 2 | 1.0414 | Electrical - Loads - Receptacle Connected: 174375; Receptacle Estimated Demand: 141007; Receptacle Demand Factor: 0.808642; Receptacle Estimated Demand Current: 36.362; Receptacle Connected Current: 44.9667
N21E:858856 | 1E19 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 12 | F21E | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | N21E | ELEC. ROOM 1E19-M | 3 | 0.8128
F21E:859016 | 1E19 | 0.633547 | 103.923 | 118188 | 91.5 | 112.269 | 113.769 | 403001 | 65.8401 | 141438 | 255320 | 143375 | 12 | MS2 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | F21E | ELEC. ROOM 1E19-M | 4 | 0.8128 | Electrical - Loads - Receptacle Connected: 403001; Receptacle Estimated Demand: 255320; Receptacle Demand Factor: 0.633547; Receptacle Estimated Demand Current: 65.8401; Receptacle Connected Current: 103.923
F41E:859225 | 1E19 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 12 | MS2 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | F41E | ELEC. ROOM 1E19-M | 5 | 0.8128
E41E:859289 | 1E19 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 12 | F41E | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | E41E | ELEC. ROOM 1E19-M | 6 | 0.8128
N21B:860380 | 1B23 | 0.896825 | 34.9741 | 38750.1 | 30 | 36.9231 | 39.9231 | 135625 | 31.3657 | 46500.1 | 121632 | 50375.1 | 36 | F22B | Level: Level 1 | Grid : C | N21B | ELEC. ROOM 1B23-M | 8 | 1.0414 | Electrical - Loads - Receptacle Connected: 135625; Receptacle Estimated Demand: 121632; Receptacle Demand Factor: 0.896825; Receptacle Estimated Demand Current: 31.3657; Receptacle Connected Current: 34.9741
N21B1:860405 | 1B23 | 0.801932 | 45.966 | 58125.1 | 45.4615 | 42 | 51.4615 | 178250 | 36.8616 | 54250.1 | 142945 | 65875.1 | 36 | F22B | Level: Level 1 | Grid : C | N21B1 | ELEC. ROOM 1B23-M | 9 | 1.0414 | Electrical - Loads - Receptacle Connected: 178250; Receptacle Estimated Demand: 142945; Receptacle Demand Factor: 0.801932; Receptacle Estimated Demand Current: 36.8616; Receptacle Connected Current: 45.966
N21B2:860552 | 1B23 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 12 | F22B | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | N21B2 | ELEC. ROOM 1B23-M | 10 | 0.8128
L41B:860639 | 1B23 | 0.476263 | 42.8683 | 44433.4 | 34.4359 | 34.1667 | 60.1692 | 166238 | 20.4165 | 44132 | 79172.9 | 77672.4 | 12 | F42B | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | L41B | ELEC. ROOM 1B23-M | 11 | 0.8128 | Electrical - Loads - Lighting - Dwelling Unit Estimated Demand: 79172.9; Lighting - Dwelling Unit Connected: 166238; Lighting - Dwelling Unit Connected Current: 42.8683; Lighting - Dwelling Unit Demand Factor: 0.476263; Lighting - Dwelling Unit Estimated Demand Current: 20.4165; Other Connected Current: 0; Other Estimated Demand: 0; Other Estimated Demand Current: 0; Other Connected: 0
N21C:861177 | Level 1 | 0.801932 | 45.966 | 58125.1 | 46.8462 | 33 | 61.8462 | 178250 | 36.8616 | 42625.1 | 142945 | 77500.2 | 36 | F22C | Level: Level 1 | Grid : 6.7 | N21C |  | 14 | 1.0414 | Electrical - Loads - Receptacle Connected: 178250; Receptacle Estimated Demand: 142945; Receptacle Demand Factor: 0.801932; Receptacle Estimated Demand Current: 36.8616; Receptacle Connected Current: 45.966
N21C1:861212 | Level 1 | 0.846262 | 49.7465 | 81504.3 | 63.9077 | 46.5577 | 40.5 | 192911 | 42.0985 | 59093.9 | 163253 | 52312.6 | 36 | F22C | Level: Level 1 | Grid : 6.7 | N21C1 |  | 15 | 1.0414 | Electrical - Loads - Receptacle Connected: 139500; Receptacle Estimated Demand: 123570; Receptacle Demand Factor: 0.885802; Receptacle Estimated Demand Current: 31.8653; Receptacle Connected Current: 35.9734; Lighting - Dwelling Unit Estimated Demand: 39683.3; Lighting - Dwelling Unit Connected: 53410.5; Lighting - Dwelling Unit Connected Current: 13.7731; Lighting - Dwelling Unit Demand Factor: 0.742987; Lighting - Dwelling Unit Estimated Demand Current: 10.2333; Other Connected Current: 0; Other Estimated Demand: 0; Other Estimated Demand Current: 0; Other Connected: 0
L41C:861513 | Level 1 | 0.474601 | 43.4401 | 40472.3 | 31.3333 | 48.7372 | 54.9872 | 168455 | 20.6167 | 59955 | 79948.9 | 68027.9 | 12 | F42C | Level: Level 1 | Grid : 6.7 | L41C |  | 16 | 0.8128 | Electrical - Loads - Lighting - Dwelling Unit Estimated Demand: 79948.9; Lighting - Dwelling Unit Connected: 168455; Lighting - Dwelling Unit Connected Current: 43.4401; Lighting - Dwelling Unit Demand Factor: 0.474601; Lighting - Dwelling Unit Estimated Demand Current: 20.6167; Other Connected Current: 0; Other Estimated Demand: 0; Other Estimated Demand Current: 0; Other Connected: 0
2SITE:936184 | 2B13 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 12 |  | Level: Level 2 | Grid : C | 2SITE | ELECTRICAL 2B13-M | 17 | 0.8128
N22B2:936228 | 2B13 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 12 | F22B | Level: Level 2 | Grid : C | N22B2 | ELECTRICAL 2B13-M | 18 | 0.8128
N22B1:936279 | 2B13 | 0.762055 | 52.9608 | 75562.7 | 61.5 | 39 | 64.5 | 205375 | 40.359 | 50375.1 | 156507 | 79437.7 | 36 | F22B | Level: Level 2 | Grid : C | N22B1 | ELECTRICAL 2B13-M | 19 | 1.0414 | Electrical - Loads - Receptacle Connected: 205375; Receptacle Estimated Demand: 156507; Receptacle Demand Factor: 0.762055; Receptacle Estimated Demand Current: 40.359; Receptacle Connected Current: 52.9608
L42B:936522 | 2B13 | 0.489028 | 38.9323 | 43550.8 | 33.7167 | 44.8385 | 40.0051 | 150975 | 19.039 | 56833.4 | 73830.7 | 50590.4 | 12 | F42B | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42B | ELECTRICAL 2B13-M | 20 | 0.8128 | Electrical - Loads - Lighting - Dwelling Unit Estimated Demand: 73830.7; Lighting - Dwelling Unit Connected: 150975; Lighting - Dwelling Unit Connected Current: 38.9323; Lighting - Dwelling Unit Demand Factor: 0.489028; Lighting - Dwelling Unit Estimated Demand Current: 19.039; Other Connected Current: 0; Other Estimated Demand: 0; Other Estimated Demand Current: 0; Other Connected: 0
F42B:936707 | 2B13 | 0.416169 | 81.8005 | 87984.2 | 68.1167 | 79.7128 | 100.846 | 317212 | 34.0428 | 100965 | 132014 | 128263 | 12 | MS2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | F42B | ELECTRICAL 2B13-M | 21 | 0.8128 | Electrical - Loads - Lighting - Dwelling Unit Estimated Demand: 132014; Lighting - Dwelling Unit Connected: 317212; Lighting - Dwelling Unit Connected Current: 81.8005; Lighting - Dwelling Unit Demand Factor: 0.416169; Lighting - Dwelling Unit Estimated Demand Current: 34.0428; Other Connected Current: 0; Other Estimated Demand: 0; Other Estimated Demand Current: 0; Other Connected: 0
N22B:937047 | 2B13 | 0.777778 | 49.963 | 58125.1 | 45 | 45 | 60 | 193750 | 38.8601 | 58125.1 | 150695 | 77500.2 | 36 | F22B | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | N22B | ELECTRICAL 2B13-M | 22 | 1.0414 | Electrical - Loads - Receptacle Connected: 193750; Receptacle Estimated Demand: 150695; Receptacle Demand Factor: 0.777778; Receptacle Estimated Demand Current: 38.8601; Receptacle Connected Current: 49.963
F22B:937316 | 2B13 | 0.575483 | 183.864 | 230563 | 181.038 | 162 | 214.038 | 713001 | 105.811 | 209250 | 410320 | 273188 | 24 | MS2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | F22B | ELECTRICAL 2B13-M | 23 | 0.8128 | Electrical - Loads - Receptacle Connected: 713001; Receptacle Estimated Demand: 410320; Receptacle Demand Factor: 0.575483; Receptacle Estimated Demand Current: 105.811; Receptacle Connected Current: 183.864
F42C:938813 | 2C18 | 0.413742 | 84.9149 | 89082.1 | 68.9667 | 70.4474 | 115.914 | 329290 | 35.1329 | 90739.8 | 136241 | 149468 | 36 | MS2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | F42C | ELECTRICAL 2C18-M | 24 | 1.0414 | Electrical - Loads - Lighting - Dwelling Unit Estimated Demand: 136241; Lighting - Dwelling Unit Connected: 329290; Lighting - Dwelling Unit Connected Current: 84.9149; Lighting - Dwelling Unit Demand Factor: 0.413742; Lighting - Dwelling Unit Estimated Demand Current: 35.1329; Other Connected Current: 0; Other Estimated Demand: 0; Other Estimated Demand Current: 0; Other Connected: 0
F22C:938873 | 2C18 | 0.583565 | 206.131 | 276280 | 217.327 | 190.682 | 216.434 | 799350 | 120.291 | 246298 | 466472 | 275126 | 36 | MS2 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | F22C | ELECTRICAL 2C18-M | 25 | 1.0414 | Electrical - Loads - Receptacle Connected: 745939; Receptacle Estimated Demand: 426789; Receptacle Demand Factor: 0.57215; Receptacle Estimated Demand Current: 110.057; Receptacle Connected Current: 192.358; Lighting - Dwelling Unit Estimated Demand: 39683.3; Lighting - Dwelling Unit Connected: 53410.5; Lighting - Dwelling Unit Connected Current: 13.7731; Lighting - Dwelling Unit Demand Factor: 0.742987; Lighting - Dwelling Unit Estimated Demand Current: 10.2333; Other Connected Current: 0; Other Estimated Demand: 0; Other Estimated Demand Current: 0; Other Connected: 0
N22C:939057 | 2C18 | 0.786369 | 48.4641 | 62000.1 | 48.4615 | 45 | 52.9615 | 187938 | 38.1107 | 58125.1 | 147788 | 67812.6 | 36 | F22C | Level: Level 2 | Grid : 7 | N22C | ELECTRICAL 2C18-M | 26 | 1.0414 | Electrical - Loads - Receptacle Connected: 187938; Receptacle Estimated Demand: 147788; Receptacle Demand Factor: 0.786369; Receptacle Estimated Demand Current: 38.1107; Receptacle Connected Current: 48.4641
N22C1:939133 | 2C18 | 0.727687 | 60.9549 | 75562.7 | 58.7308 | 67.7308 | 57 | 236375 | 44.356 | 87187.7 | 172007 | 73625.1 | 36 | F22C | Level: Level 2 | Grid : 7 | N22C1 | ELECTRICAL 2C18-M | 27 | 1.0414 | Electrical - Loads - Receptacle Connected: 236375; Receptacle Estimated Demand: 172007; Receptacle Demand Factor: 0.727687; Receptacle Estimated Demand Current: 44.356; Receptacle Connected Current: 60.9549
N22C2:939184 | 2C18 | 1 | 0.99926 | 0 | 0 | 0 | 3 | 3875.01 | 0.99926 | 0 | 3875.01 | 3875.01 | 12 | F22C | Level: Level 2 | Grid : 7 | N22C2 | ELECTRICAL 2C18-M | 28 | 0.8128 | Electrical - Loads - Receptacle Connected: 3875.01; Receptacle Estimated Demand: 3875.01; Receptacle Demand Factor: 1; Receptacle Estimated Demand Current: 0.99926; Receptacle Connected Current: 0.99926
2MEC:939396 | 2C18 | 1 | 2.88675 | 3731.49 | 2.88889 | 2.88889 | 2.88889 | 11194.5 | 2.88675 | 3731.49 | 11194.5 | 3731.49 | 12 |  | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | 2MEC | ELECTRICAL 2C18-M | 30 | 0.8128 | Electrical - Loads - Cooling Estimated Demand Current: 2.88675; Cooling Connected Current: 2.88675; Cooling Connected: 11194.5; Cooling Demand Factor: 1; Cooling Estimated Demand: 11194.5
L42C:939569 | 2C18 | 0.480505 | 41.4748 | 48609.8 | 39.7564 | 23.8333 | 65.1731 | 160834 | 19.9289 | 30784.8 | 77281.6 | 81439.7 | 12 | F42C | Level: Level 2 | Linked Revit Model : Clinic_A.rvt | L42C | ELECTRICAL 2C18-M | 31 | 0.8128 | Electrical - Loads - Lighting - Dwelling Unit Estimated Demand: 77281.6; Lighting - Dwelling Unit Connected: 160834; Lighting - Dwelling Unit Connected Current: 41.4748; Lighting - Dwelling Unit Demand Factor: 0.480505; Lighting - Dwelling Unit Estimated Demand Current: 19.9289; Other Connected Current: 0; Other Estimated Demand: 0; Other Estimated Demand Current: 0; Other Connected: 0
1MEC:1063416 | 1E15 | 1 | 2.88675 | 3731.49 | 2.88889 | 2.88889 | 2.88889 | 11194.5 | 2.88675 | 3731.49 | 11194.5 | 3731.49 | 12 |  | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 1MEC | CENTRAL MECH. RM. 1E15-M | 32 | 0.8128 | Electrical - Loads - Cooling Estimated Demand Current: 2.88675; Cooling Connected Current: 2.88675; Cooling Connected: 11194.5; Cooling Demand Factor: 1; Cooling Estimated Demand: 11194.5

# IfcEnergyConversionDevice: 633-703 kW, M_Screw Chiller - Air Cooled - 281-1231 kW:633-703 kW:633-703 kW:1066741
In: Level 1
Type - ElementType: 633-703 kW; PredefinedType: USERDEFINED; Classification:  (UniFormat)
Identity Data - OmniClass Number: 23.75.10.24.21.21.21; OmniClass Title: Rotary-Screw Water Chillers; Manufacturer: N/A; Mark: ACC-1
Electrical - Number of Poles: 3; Load Classification: Cooling; Voltage: 4951.4
Dimensions - C1 Offset 2: 0.571 m; C1 Offset 1: 1.782 m; Chiller Length: 7.168 m; Chilled Water Supply Diameter: 0.492126; Chilled Water Return Diameter: 0.489501; C2 Offset 2: 0.287 m; Chilled Water Supply Radius: 0.246063; Chilled Water Return Radius: 0.244751; C1 Offset 3: 4.512 m
Other - ExpectedLife: N/A; WarrantyDurationLabor: N/A; ReplacementCost: N/A; ModelLabel: N/A; NominalWidth: 0; RatedCurrent: 0; Length 2: 0.2524 m; NumberOfPoles: 0; WarrantyGuarantorParts: N/A; Radius 1: 0.227 m; NominalLength: 0; WarrantyGuarantorLabor: N/A; WarrantyDurationParts: N/A; ModelReference: N/A; Constituents: N/A; AssetAccountingType: FIXED; ConductorFunction: L1; Size: 0; Grade: N/A; Features: N/A; Half Number of Fans: 6; Number of Fans: 12; Shape: N/A; AccessibilityPerformance: N/A; WarrantyDescription: N/A; NominalHeight: 0; Material: N/A; ProductionYear: N/A; HasProtectiveEarth: TRUE; NominalFrequencyRange: 0; IP_Code: 0; PowerFactor: 0; SustainabilityPerformance: N/A; CodePerformance: N/A; Length 1: 1.565 m; RatedVoltage: 0; InstallationDate: N/A; WarrantyStartDate: N/A; AssetIdentifier: N/A; BarCode: N/A; TagNumber: N/A; SerialNumber: N/A
Constraints - Level: Level: Level 1; Host: Level : Level 1; Offset: 0 m
Electrical - Loads - Panel: MS1; Circuit Number: 3; Apparent Load: 985974
Mechanical - Cold Capacity: 2857700; Chilled Water Flow: 0.388461; Drain Flow: 0; System Classification: Hydronic Return,Hydronic Supply,Sanitary,Power; Chilled Water Pressure Drop: 10570.5; System Name: Hydronic Return 1,Hydronic Supply 1,Sanitary 1
Phasing - Phase Created: New Construction

# IfcEnergyConversionDevice: 914mmx673mm (2)
In: 1B23
Type - ElementType: 914mmx673mm; PredefinedType: VOLTAGE; Classification:  (UniFormat)
Identity Data - Manufacturer: N/A; OmniClass Title: Distribution Boards and Control Panels; OmniClass Number: 23.80.30.11.17
Dimensions - Switchboard Height: 2.286 m; Switchboard Width: 0.673 m; Switchboard Length: 0.914 m
Electrical - Primary Voltage: 2238.89; Load Classification: Other; Primary Number of Poles: 3
Other - ReplacementCost: N/A; AssetAccountingType: FIXED; IsSkilledOperator: TRUE; Half Switchboard Length: 0.457 m; AccessibilityPerformance: N/A; ModelReference: N/A; WarrantyDescription: N/A; WarrantyGuarantorParts: N/A; WarrantyGuarantorLabor: N/A; RatedCurrent: 0; Grade: N/A; NominalLength: 0; RatedVoltage: 0; Height 1: 2.286 m; SustainabilityPerformance: N/A; Material: N/A; NominalFrequencyRange: 0; WarrantyDurationLabor: N/A; Constituents: N/A; ExpectedLife: N/A; NominalWidth: 0; ProductionYear: N/A; Shape: N/A; Panel Length: 0.8124 m; CodePerformance: N/A; Size: 0; ModelLabel: N/A; PowerFactor: 0; WarrantyDurationParts: N/A; ConductorFunction: L1; HasProtectiveEarth: TRUE; NominalHeight: 0; Panel Height: 0.508 m; NumberOfPoles: 0; Length 1: 0.914 m; Features: N/A; IP_Code: 0; AssetIdentifier: N/A; TagNumber: N/A; SerialNumber: N/A; WarrantyStartDate: N/A; BarCode: N/A; InstallationDate: N/A
Electrical - Loads - Appliance - Dwelling Unit Demand Factor: 1
Electrical - Circuiting - Number of Wires: 4; Number of Phases: 3; Electrical Data: 208 V/3-0 VA; Mains: 100
General - Mounting: Recessed; Location: ELEC. ROOM 1B23-M; Enclosure: Type 1
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 m
Phasing - Phase Created: New Construction
