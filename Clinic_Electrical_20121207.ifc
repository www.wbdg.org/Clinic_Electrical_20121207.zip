Properties of the parts of a building model (IFC2X3), part 5 of 7

# IfcFlowTerminal: Q4 - 1219mm - 1m Drop (38)
Name (M_Pendant Light - Linear:Q4 - 1219mm - 1m Drop:Q4 - 1219mm - 1m Drop:...) | In | Schedule Level | Host | Elevation (m) | Panel | Circuit Number
826374 | 1E03 | Level: Level 1 | <not associated> | 2.8 | L41B | 3
827331 | 1E17 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 6

# IfcFlowTerminal: Q4B - 1219mm - 1m Drop (13)
Type - ElementType: Q4B - 1219mm - 1m Drop; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Ivory, Glossy, Glass - White, High Luminance
Constraints - Default Elevation: 1.2 m
Dimensions - Light Source Symbol Size: 0.05 m; Light Casing Length: 1.2 m; Drop From Ceiling: 2 m
Electrical - Wattage Comments: 32; Ballast Voltage: 1291.67; Lamp: T8, 1219mm, RAPID START, CRI=75 T8, 1219mm, RAPID START, CRI=75 T8, 1219mm, RAPID START, CRI=75; Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit
Electrical - Loads - Apparent Load: 688.89
Photometrics - Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Color: 0; Lumens: 2900; Initial Intensity: 0; Color Filter: 16777215; Dimming Lamp Color Temperature Shift: 0
Materials and Finishes - Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance
Identity Data - OmniClass Title: General Luminaries, Non Directional; Description: SAME AS Q4 EXCEPT WITH EMERGENCY BATTERY PACK.; Assembly Description: Lighting - Fluorescent; OmniClass Number: 23.80.70.11.11; Type Mark: Q4B; Manufacturer: N/A; Assembly Code: D5020210
Other - Constituents: N/A; ExpectedLife: N/A; MaintenanceFactor: 0; ProductionYear: N/A; Features: N/A; ReplacementCost: N/A; NominalLength: 0; NumberOfSources: 0; CodePerformance: N/A; HasProtectiveEarth: TRUE; NominalFrequencyRange: 0; Material: N/A; NominalHeight: 0; ModelLabel: N/A; Shape: N/A; WarrantyDurationLabor: N/A; IP_Code: 0; RatedVoltage: 0; NumberOfPoles: 0; Grade: N/A; SensibleLoadToRadiant: 0; AssetAccountingType: FIXED; WarrantyGuarantorLabor: N/A; AccessibilityPerformance: N/A; MaximumSpaceSensibleLoad: 0; RatedCurrent: 0; WarrantyDescription: N/A; SustainabilityPerformance: N/A; Size: 0; NominalWidth: 0; ConductorFunction: L1; ModelReference: N/A; WarrantyGuarantorParts: N/A; PowerFactor: 0; WarrantyDurationParts: N/A; TotalWattage: 0; MaximumPlenumSensibleLoad: 0; SerialNumber: N/A; InstallationDate: N/A; TagNumber: N/A; WarrantyStartDate: N/A; BackupSupplySystem: YES; FixtureHeight: 0; Reference: REF TYPE MARK; AssetIdentifier: N/A; BarCode: N/A
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-64 VA
Name (M_Pendant Light - Linear:Q4B - 1219mm - 1m Drop:Q4B - 1219mm - 1m Drop:...) | In | Schedule Level | Panel | Circuit Number | Elevation (m) | Host
744837 | 1E15 | Level: Level 1 | L41B | 5 | 2.68 | Linked Revit Model : Clinic_A.rvt
745835 | 1E20 | Level: Level 1 | L41B | 6 | 2.68 | Linked Revit Model : Clinic_A.rvt
746053 | 1E19 | Level: Level 1 | L41B | 6 | 2.68 | Linked Revit Model : Clinic_A.rvt
750581 | 1B21 | Level: Level 1 | L41B | 1 | 2.68 | Linked Revit Model : Clinic_A.rvt
750780 | 1B23 | Level: Level 1 | L41B | 8 | 2.68 | Linked Revit Model : Clinic_A.rvt
774387 | 2D05 | Level: Level 2 | L42C | 9 | 4.68 | Linked Revit Model : Clinic_S.rvt
774861 | 2D05 | Level: Level 2 | L42C | 9 | 4.68 | Linked Revit Model : Clinic_S.rvt
775688 | 2D05 | Level: Level 2 | L42C | 9 | 4.68 | Linked Revit Model : Clinic_S.rvt
776018 | 2D05 | Level: Level 2 | L42C | 9 | 4.68 | Linked Revit Model : Clinic_S.rvt
776471 | 2B13 | Level: Level 2 | L42B | 3 | 2.68 | Linked Revit Model : Clinic_A.rvt
776596 | 2B12 | Level: Level 2 | L42B | 3 | 2.68 | Linked Revit Model : Clinic_A.rvt
783301 | 2C18 | Level: Level 2 | L42C | 1 | 4.6735 | Linked Revit Model : Clinic_S.rvt
783328 | 2C15 | Level: Level 2 | L42C | 1 | 4.6735 | Linked Revit Model : Clinic_S.rvt

# IfcFlowTerminal: R1 - 305x1219mm (4)
Type - ElementType: R1 - 305x1219mm; Classification: D5020210 Lighting - Fluorescent (UniFormat)
Material: Metal - Paint Finish - Dark Gray, Matte, Metal - Chrome, Glass - White, High Luminance
Electrical - Loads - Apparent Load: 861.113; Panel: L41B; Circuit Number: 1
Constraints - Default Elevation: 1.2 m; Elevation: 2.68 m; Host: Linked Revit Model : Clinic_A.rvt
Materials and Finishes - Grid Material: Metal - Paint Finish - Dark Gray, Matte; Light Box Material: Metal - Chrome; Diffuser Material: Glass - White, High Luminance
Dimensions - Light Source Symbol Size: 0.05 m
Other - NominalLength: 0; MaximumSpaceSensibleLoad: 0; WarrantyDurationParts: N/A; PowerFactor: 0; WarrantyDescription: N/A; Features: N/A; AccessibilityPerformance: N/A; AssetAccountingType: FIXED; ProductionYear: N/A; TotalWattage: 0; NominalWidth: 0; HasProtectiveEarth: TRUE; WarrantyGuarantorParts: N/A; NominalFrequencyRange: 0; RatedCurrent: 0; MaximumPlenumSensibleLoad: 0; Constituents: N/A; ModelLabel: N/A; IP_Code: 0; WarrantyGuarantorLabor: N/A; ConductorFunction: L1; NumberOfPoles: 0; Size: 0; WarrantyDurationLabor: N/A; ReplacementCost: N/A; Material: N/A; ModelReference: N/A; NominalHeight: 0; Shape: N/A; Grade: N/A; NumberOfSources: 0; RatedVoltage: 0; SensibleLoadToRadiant: 0; ExpectedLife: N/A; CodePerformance: N/A; SustainabilityPerformance: N/A; MaintenanceFactor: 0; BackupSupplySystem: NO; Reference: REF TYPE MARK; Schedule Level: Level: Level 1; InstallationDate: N/A; AssetIdentifier: N/A; WarrantyStartDate: N/A; TagNumber: N/A; BarCode: N/A; SerialNumber: N/A; FixtureHeight: 0
Identity Data - Description: 305mm x 1219mm (NOMINAL) RECESSED TROFFER A-12 PRISMATIC LENS, BAKED WHITE ENAMEL FINISH; Manufacturer: N/A; Assembly Code: D5020210; OmniClass Number: 23.80.70.11.14.11; Assembly Description: Lighting - Fluorescent; Type Mark: R1; OmniClass Title: Downlights
Electrical - Load Classification: Lighting - Dwelling Unit; Lamp: T8, 1219mm, RAPID START, CRI=75 T8, 1219mm, RAPID START, CRI=75 T8, 1219mm, RAPID START, CRI=75 T8, 1219mm, RAPID START, CRI=75 T8, 1219mm, RAPID START, CRI=75; Ballast Number of Poles: 1; Wattage Comments: 32; Ballast Voltage: 1291.67
Photometrics - Lumens: 1800; Dimming Lamp Color Temperature Shift: 0; Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Color: 0; Color Filter: 16777215; Initial Intensity: 0
Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Name (M_Troffer Light - Parabolic Rectangular:R1 - 305x1219mm:R1 - 305x1219mm:...) | In
745356 | 1B14
745370 | 1B12
745477 | 1B09
745555 | 1B07

# IfcFlowTerminal: S - 203mm Diameter (9)
In: 2A01
Type - ElementType: S - 203mm Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Electrical - Loads - Apparent Load: 1076.39; Panel: L42C; Circuit Number: 6
Dimensions - Light Source Symbol Size: 0.05 m; Recessing Height: 0.2 m; Recessing Diameter: 0.2 m
Photometrics - Color Filter: 16777215; Light Source Definition (family): Point+HemiSpherical; Lumens: 2900; Dimming Lamp Color Temperature Shift: 0; Initial Color: 0; Initial Intensity: 0; Light Loss Factor: 0
Other - ModelLabel: N/A; HasProtectiveEarth: TRUE; Grade: N/A; SustainabilityPerformance: N/A; AssetAccountingType: FIXED; NominalWidth: 0; WarrantyDescription: N/A; Recessing Inner Radius: 0.0873 m; WarrantyDurationParts: N/A; NominalFrequencyRange: 0; Constituents: N/A; AccessibilityPerformance: N/A; ProductionYear: N/A; WarrantyDurationLabor: N/A; MaximumSpaceSensibleLoad: 0; PowerFactor: 0; TotalWattage: 0; WarrantyGuarantorLabor: N/A; NominalHeight: 0; WarrantyGuarantorParts: N/A; Features: N/A; ReplacementCost: N/A; NominalLength: 0; Recessing Radius: 0.1 m; SensibleLoadToRadiant: 0; CodePerformance: N/A; NumberOfSources: 0; MaximumPlenumSensibleLoad: 0; ExpectedLife: N/A; RatedVoltage: 0; Shape: N/A; IP_Code: 0; NumberOfPoles: 0; Size: 0; ConductorFunction: L1; RatedCurrent: 0; ModelReference: N/A; MaintenanceFactor: 0; Material: N/A; SerialNumber: N/A; BackupSupplySystem: NO; FixtureHeight: 0; AssetIdentifier: N/A; InstallationDate: N/A; TagNumber: N/A; BarCode: N/A; WarrantyStartDate: N/A; Schedule Level: Level: Level 2; Reference: REF TYPE MARK
Identity Data - Assembly Code: D5020220; Manufacturer: N/A; OmniClass Number: 23.80.70.11.14.11; Description: RECESSED INCANDESCENT DOWNLIGHT; OmniClass Title: Downlights; Type Mark: S; Assembly Description: Lighting - Incandescent
Constraints - Default Elevation: 1.2 m; Elevation: 2.68 m; Host: Linked Revit Model : Clinic_A.rvt
Electrical - Ballast Number of Poles: 1; Wattage Comments: 75; Ballast Voltage: 1291.67; Load Classification: Lighting - Dwelling Unit; Lamp: PAR 38
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Name (M_Downlight - Recessed Can:S - 203mm Diameter:S - 203mm Diameter:...)
778151
778229
778312
778364
778414
778608
778668
778744
778810

# IfcFlowTerminal: SA - 152mm Diameter (3)
Type - ElementType: SA - 152mm Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Constraints - Default Elevation: 1.2 m; Host: <not associated>; Elevation: 2.8 m
Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: 0; Lumens: 950; Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Initial Intensity: 0; Light Loss Factor: 0
Identity Data - Assembly Code: D5020220; Assembly Description: Lighting - Incandescent; Type Mark: SA; Manufacturer: N/A; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights; Description: RECESSED FLOURESCENT SHOWER LIGHT, 152mm DIAMETER APERTURE, DROP OPAL LENS, UL LISTED FOR WET LOCATIONS
Other - RatedCurrent: 0; AccessibilityPerformance: N/A; ExpectedLife: N/A; NominalLength: 0; SustainabilityPerformance: N/A; TotalWattage: 0; PowerFactor: 0; NominalFrequencyRange: 0; WarrantyDescription: N/A; NominalHeight: 0; WarrantyDurationParts: N/A; HasProtectiveEarth: TRUE; ModelReference: N/A; IP_Code: 0; RatedVoltage: 0; ProductionYear: N/A; WarrantyGuarantorLabor: N/A; Shape: N/A; Constituents: N/A; Recessing Inner Radius: 0.0873 m; Recessing Radius: 0.1 m; MaintenanceFactor: 0; NumberOfSources: 0; WarrantyGuarantorParts: N/A; SensibleLoadToRadiant: 0; NumberOfPoles: 0; MaximumSpaceSensibleLoad: 0; CodePerformance: N/A; ReplacementCost: N/A; MaximumPlenumSensibleLoad: 0; WarrantyDurationLabor: N/A; Material: N/A; NominalWidth: 0; ModelLabel: N/A; Grade: N/A; AssetAccountingType: FIXED; Size: 0; ConductorFunction: L1; Features: N/A; BackupSupplySystem: NO; SerialNumber: N/A; WarrantyStartDate: N/A; BarCode: N/A; FixtureHeight: 0; InstallationDate: N/A; Reference: REF TYPE MARK; TagNumber: N/A; AssetIdentifier: N/A
Dimensions - Recessing Height: 0.2 m; Light Source Symbol Size: 0.05 m; Recessing Diameter: 0.2 m
Electrical - Loads - Apparent Load: 1076.39
Electrical - Ballast Number of Poles: 1; Wattage Comments: 13; Ballast Voltage: 1291.67; Lamp: T4, TWIN TUBE, CRI=82 T4, TWIN TUBE, CRI=82 T4, TWIN TUBE, CRI=82 T4, TWIN TUBE, CRI=82; Load Classification: Lighting - Dwelling Unit
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Name (M_Downlight - Recessed Can:SA - 152mm Diameter:SA - 152mm Diameter:...) | In | Schedule Level | Panel | Circuit Number
783090 | 2C08 | Level: Level 2 | L42C | 2
784102 | 2C07 | Level: Level 2 | L42C | 2
809668 | 1D18 | Level: Level 1 | L41C | 5

# IfcFlowTerminal: SB - 102mm Diameter (48)
Type - ElementType: SB - 102mm Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Constraints - Default Elevation: 1.2 m; Host: Linked Revit Model : Clinic_A.rvt
Photometrics - Lumens: 1200; Light Loss Factor: 0; Light Source Definition (family): Point+HemiSpherical; Color Filter: 16777215; Initial Intensity: 0; Dimming Lamp Color Temperature Shift: 0; Initial Color: 0
Electrical - Loads - Apparent Load: 1076.39
Electrical - Wattage Comments: 18; Ballast Number of Poles: 1; Ballast Voltage: 1291.67; Lamp: T4, QUAD TUBE, CRI=82; Load Classification: Lighting - Dwelling Unit
Dimensions - Light Source Symbol Size: 0.05 m; Recessing Diameter: 0.2 m; Recessing Height: 0.2 m
Identity Data - OmniClass Title: Downlights; Assembly Description: Lighting - Incandescent; OmniClass Number: 23.80.70.11.14.11; Manufacturer: N/A; Description: RECESSED COMPACT FLOURESCENT DOWNLIGHT WITH 102mm DIAMETER CEILING APERTURE, CLEAR SPECULAR REFLECTORS, WHITE TRIM RING; Assembly Code: D5020220; Type Mark: SB
Other - PowerFactor: 0; IP_Code: 0; ConductorFunction: L1; ModelLabel: N/A; NumberOfPoles: 0; Size: 0; Recessing Radius: 0.1 m; Grade: N/A; AssetAccountingType: FIXED; RatedCurrent: 0; NominalHeight: 0; RatedVoltage: 0; Shape: N/A; HasProtectiveEarth: TRUE; ProductionYear: N/A; SustainabilityPerformance: N/A; NumberOfSources: 0; WarrantyDescription: N/A; AccessibilityPerformance: N/A; MaximumPlenumSensibleLoad: 0; ModelReference: N/A; WarrantyDurationParts: N/A; Recessing Inner Radius: 0.0873 m; NominalFrequencyRange: 0; WarrantyGuarantorParts: N/A; Material: N/A; MaximumSpaceSensibleLoad: 0; WarrantyGuarantorLabor: N/A; ExpectedLife: N/A; NominalLength: 0; Constituents: N/A; ReplacementCost: N/A; MaintenanceFactor: 0; WarrantyDurationLabor: N/A; CodePerformance: N/A; NominalWidth: 0; Features: N/A; SensibleLoadToRadiant: 0; TotalWattage: 0; AssetIdentifier: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; FixtureHeight: 0; TagNumber: N/A; BackupSupplySystem: NO; BarCode: N/A; SerialNumber: N/A; Reference: REF TYPE MARK
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Name (M_Downlight - Recessed Can:SB - 102mm Diameter:SB - 102mm Diameter:...) | In | Schedule Level | Elevation (m) | Panel | Circuit Number
746741 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
746836 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
746870 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
746910 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
746973 | 1DC1 | Level: Level 1 | 2.68 | L41C | 6
747095 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
747203 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
747243 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
747315 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
747370 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
747461 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
747509 | 1D22 | Level: Level 1 | 2.68 | L41C | 5
747543 | 1D22 | Level: Level 1 | 2.68 | L41C | 5
747680 | 1DC1 | Level: Level 1 | 2.68 | L41C | 6
747745 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
747783 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
747831 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
747929 | 1DC1 | Level: Level 1 | 2.68 | L41C | 6
748022 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
748080 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
748138 | 1DC1 | Level: Level 1 | 2.8 | L41C | 6
748595 | 1C02 | Level: Level 1 | 2.68 | N21C1 | 22
748650 | 1C02 | Level: Level 1 | 2.68 | N21C1 | 22
748712 | 1C02 | Level: Level 1 | 2.68 | N21C1 | 22
748764 | 1C10 | Level: Level 1 | 2.68 | N21C1 | 22
748855 | 1C10 | Level: Level 1 | 2.68 | N21C1 | 22
748879 | 1C10 | Level: Level 1 | 2.68 | N21C1 | 22
748906 | 1C10 | Level: Level 1 | 2.68 | N21C1 | 22
748928 | 1C10 | Level: Level 1 | 2.68 | N21C1 | 22
748970 | 1C07 | Level: Level 1 | 2.68 | N21C1 | 22
749027 | 1C07 | Level: Level 1 | 2.68 | N21C1 | 22
749067 | 1C07 | Level: Level 1 | 2.68 | N21C1 | 22
749099 | 1C07 | Level: Level 1 | 2.68 | N21C1 | 22
749133 | 1C07 | Level: Level 1 | 2.68 | N21C1 | 22
780694 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
780937 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
781006 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
781031 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
781098 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
781184 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
781289 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
781328 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
781411 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
781444 | 2D18 | Level: Level 2 | 2.68 | L42B | 5
782024 | 2BC1 | Level: Level 2 | 2.68 | L42B | 4
782088 | 2BC1 | Level: Level 2 | 2.68 | L42B | 4
782227 | Level 2 | Level: Level 2 | 2.68 | L42B | 4
782263 | Level 2 | Level: Level 2 | 2.68 | L42B | 4

# IfcFlowTerminal: SBB - 102 Diameter (9)
Type - ElementType: SBB - 102 Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Electrical - Wattage Comments: 18; Ballast Voltage: 1291.67; Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Lamp: T4, QUAD TUBE, CRI=82
Constraints - Default Elevation: 1.2 m; Host: Linked Revit Model : Clinic_A.rvt; Elevation: 2.68 m
Identity Data - Assembly Description: Lighting - Incandescent; OmniClass Title: Downlights; Type Mark: SBB; Assembly Code: D5020220; Description: SAME AS SB EXCEPT WITH EMERGENCY BATTERY PACK.; Manufacturer: N/A; OmniClass Number: 23.80.70.11.14.11
Photometrics - Light Loss Factor: 0; Initial Color: 0; Initial Intensity: 0; Color Filter: 16777215; Lumens: 1200; Dimming Lamp Color Temperature Shift: 0; Light Source Definition (family): Point+HemiSpherical
Electrical - Loads - Apparent Load: 1076.39
Dimensions - Recessing Diameter: 0.2 m; Light Source Symbol Size: 0.05 m; Recessing Height: 0.2 m
Other - NominalHeight: 0; NominalWidth: 0; Recessing Inner Radius: 0.0873 m; NominalLength: 0; TotalWattage: 0; MaintenanceFactor: 0; AccessibilityPerformance: N/A; ProductionYear: N/A; MaximumPlenumSensibleLoad: 0; NumberOfPoles: 0; AssetAccountingType: FIXED; NumberOfSources: 0; SustainabilityPerformance: N/A; WarrantyGuarantorParts: N/A; ModelReference: N/A; Material: N/A; WarrantyGuarantorLabor: N/A; Grade: N/A; WarrantyDescription: N/A; NominalFrequencyRange: 0; Constituents: N/A; ReplacementCost: N/A; ConductorFunction: L1; SensibleLoadToRadiant: 0; CodePerformance: N/A; IP_Code: 0; Recessing Radius: 0.1 m; RatedCurrent: 0; WarrantyDurationParts: N/A; Shape: N/A; PowerFactor: 0; Size: 0; MaximumSpaceSensibleLoad: 0; ExpectedLife: N/A; WarrantyDurationLabor: N/A; ModelLabel: N/A; RatedVoltage: 0; HasProtectiveEarth: TRUE; Features: N/A; InstallationDate: N/A; SerialNumber: N/A; WarrantyStartDate: N/A; Reference: REF TYPE MARK; BackupSupplySystem: YES; BarCode: N/A; TagNumber: N/A; AssetIdentifier: N/A; FixtureHeight: 0
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Name (M_Downlight - Recessed Can:SBB - 102 Diameter:SBB - 102 Diameter:...) | In | Schedule Level | Panel | Circuit Number
747965 | 1DC1 | Level: Level 1 | L41C | 6
780723 | 2D18 | Level: Level 2 | L42B | 5
780978 | 2D18 | Level: Level 2 | L42B | 5
781069 | 2D18 | Level: Level 2 | L42B | 5
781128 | 2D18 | Level: Level 2 | L42B | 5
781249 | 2D18 | Level: Level 2 | L42B | 5
781384 | 2D18 | Level: Level 2 | L42B | 5
782159 | 2BC1 | Level: Level 2 | L42B | 4
782187 | 2BC1 | Level: Level 2 | L42B | 4

# IfcFlowTerminal: SC - 213mm Diameter (24)
Type - ElementType: SC - 213mm Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Constraints - Default Elevation: 1.2 m; Host: Linked Revit Model : Clinic_A.rvt; Elevation: 2.68 m
Electrical - Ballast Voltage: 1291.67; Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit; Lamp: T4, TRIPLE TUBE, CRI=82; Wattage Comments: 32
Dimensions - Recessing Height: 0.2 m; Recessing Diameter: 0.2 m; Light Source Symbol Size: 0.05 m
Electrical - Loads - Apparent Load: 1076.39
Photometrics - Light Source Definition (family): Point+HemiSpherical; Initial Color: 0; Color Filter: 16777215; Initial Intensity: 0; Dimming Lamp Color Temperature Shift: 0; Lumens: 2400; Light Loss Factor: 0
Identity Data - Description: RECESSED COMPACT FLOURESCENT DOWNLIGHT WITH 213mm DIAMETER CEILING APERTURE, CLEAR SPECULAR REFLECTORS, WHITE TRIM RING; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights; Manufacturer: N/A; Assembly Description: Lighting - Incandescent; Type Mark: SC; Assembly Code: D5020220
Other - WarrantyDurationLabor: N/A; MaximumPlenumSensibleLoad: 0; NumberOfPoles: 0; Recessing Inner Radius: 0.0873 m; AssetAccountingType: FIXED; MaintenanceFactor: 0; ConductorFunction: L1; WarrantyDurationParts: N/A; PowerFactor: 0; AccessibilityPerformance: N/A; MaximumSpaceSensibleLoad: 0; NominalWidth: 0; TotalWattage: 0; RatedCurrent: 0; SensibleLoadToRadiant: 0; HasProtectiveEarth: TRUE; SustainabilityPerformance: N/A; ReplacementCost: N/A; NominalLength: 0; RatedVoltage: 0; CodePerformance: N/A; Constituents: N/A; NumberOfSources: 0; Recessing Radius: 0.1 m; NominalFrequencyRange: 0; Size: 0; NominalHeight: 0; WarrantyGuarantorLabor: N/A; ExpectedLife: N/A; ModelReference: N/A; Grade: N/A; WarrantyDescription: N/A; Shape: N/A; ModelLabel: N/A; ProductionYear: N/A; IP_Code: 0; Material: N/A; WarrantyGuarantorParts: N/A; Features: N/A; FixtureHeight: 0; WarrantyStartDate: N/A; Reference: REF TYPE MARK; Schedule Level: Level: Level 2; BarCode: N/A; SerialNumber: N/A; TagNumber: N/A; BackupSupplySystem: NO; AssetIdentifier: N/A; InstallationDate: N/A
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Name (M_Downlight - Recessed Can:SC - 213mm Diameter:SC - 213mm Diameter:...) | In | Circuit Number | Panel
779322 | Level 2 | 3 | L42C
779368 | Level 2 | 3 | L42C
779408 | Level 2 | 3 | L42C
779444 | Level 2 | 3 | L42C
779480 | Level 2 | 3 | L42C
779853 | 2AS1 | 7 | L42C
779897 | 2AS1 | 7 | L42C
779979 | 2AS1 | 7 | L42C
780057 | 2AS1 | 7 | L42C
780097 | 2AS1 | 7 | L42C
781718 | 2B11 | 4 | L42B
781769 | 2B11 | 4 | L42B
781817 | 2B11 | 4 | L42B
781853 | 2B11 | 4 | L42B
781897 | 2B11 | 4 | L42B
781949 | 2B11 | 4 | L42B
783354 | 2A04 | 6 | L42C
783402 | 2A04 | 6 | L42C
783430 | 2A04 | 6 | L42C
783478 | 2A03 | 6 | L42C
783538 | 2A03 | 6 | L42C
783580 | 2A03 | 6 | L42C
783739 | 2A13 | 7 | L42C
783825 | 2A12-A | 7 | L42C

# IfcFlowTerminal: SCB - 213 Diameter (5)
Type - ElementType: SCB - 213 Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Electrical - Loads - Apparent Load: 1076.39; Panel: L42C
Constraints - Default Elevation: 1.2 m; Host: Linked Revit Model : Clinic_A.rvt; Elevation: 2.68 m
Photometrics - Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215; Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Lumens: 2400; Initial Intensity: 0
Dimensions - Recessing Diameter: 0.2 m; Light Source Symbol Size: 0.05 m; Recessing Height: 0.2 m
Electrical - Ballast Voltage: 1291.67; Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit; Wattage Comments: 32; Lamp: T4, TRIPLE TUBE, CRI=82
Identity Data - Manufacturer: N/A; Assembly Code: D5020220; Type Mark: SCB; OmniClass Number: 23.80.70.11.14.11; Description: SAME AS SC EXPECT WITH EMERGENCY BATTERY PACK; Assembly Description: Lighting - Incandescent; OmniClass Title: Downlights
Other - Constituents: N/A; WarrantyGuarantorParts: N/A; Recessing Inner Radius: 0.0873 m; RatedCurrent: 0; WarrantyGuarantorLabor: N/A; Features: N/A; NominalFrequencyRange: 0; ConductorFunction: L1; NominalLength: 0; Recessing Radius: 0.1 m; CodePerformance: N/A; Grade: N/A; ModelLabel: N/A; AccessibilityPerformance: N/A; Material: N/A; ProductionYear: N/A; ModelReference: N/A; WarrantyDescription: N/A; Shape: N/A; HasProtectiveEarth: TRUE; NominalHeight: 0; NominalWidth: 0; SensibleLoadToRadiant: 0; MaximumPlenumSensibleLoad: 0; WarrantyDurationLabor: N/A; RatedVoltage: 0; PowerFactor: 0; AssetAccountingType: FIXED; NumberOfSources: 0; ReplacementCost: N/A; ExpectedLife: N/A; MaximumSpaceSensibleLoad: 0; WarrantyDurationParts: N/A; SustainabilityPerformance: N/A; IP_Code: 0; NumberOfPoles: 0; MaintenanceFactor: 0; Size: 0; TotalWattage: 0; InstallationDate: N/A; FixtureHeight: 0; Schedule Level: Level: Level 2; TagNumber: N/A; BackupSupplySystem: YES; SerialNumber: N/A; Reference: REF TYPE MARK; WarrantyStartDate: N/A; BarCode: N/A; AssetIdentifier: N/A
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Name (M_Downlight - Recessed Can:SCB - 213 Diameter:SCB - 213 Diameter:...) | In | Circuit Number
779113 | Level 2 | 3
779188 | Level 2 | 3
779791 | 2AS1 | 7
779939 | 2AS1 | 7
780013 | 2AS1 | 7

# IfcFlowTerminal: SD - 213mm Diameter (21)
Type - ElementType: SD - 213mm Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Constraints - Default Elevation: 1.2 m
Dimensions - Recessing Height: 0.2 m; Recessing Diameter: 0.2 m; Light Source Symbol Size: 0.05 m
Photometrics - Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Color Filter: 16777215; Initial Intensity: 0; Light Loss Factor: 0; Dimming Lamp Color Temperature Shift: 0; Lumens: 1800
Electrical - Ballast Number of Poles: 1; Wattage Comments: 26; Lamp: T4, QUAD TUBE, CRI=82; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67
Identity Data - OmniClass Title: Downlights; OmniClass Number: 23.80.70.11.14.11; Description: RECESSED COMPACT FLOURESCENT DOWNLIGHT WITH 213mm DIAMETER CEILING APERTURE, CLEAR POLISHED, ANODIZED ALUMINUM REFLECTORS. UL LISTED FOR DAMP LOCATION USE.; Assembly Description: Lighting - Incandescent; Manufacturer: N/A; Type Mark: SD; Assembly Code: D5020220
Other - Recessing Radius: 0.1 m; MaintenanceFactor: 0; ProductionYear: N/A; MaximumSpaceSensibleLoad: 0; Size: 0; NominalWidth: 0; ReplacementCost: N/A; NominalLength: 0; WarrantyDurationLabor: N/A; Features: N/A; WarrantyGuarantorLabor: N/A; Grade: N/A; SensibleLoadToRadiant: 0; WarrantyGuarantorParts: N/A; Material: N/A; AssetAccountingType: FIXED; RatedCurrent: 0; CodePerformance: N/A; Recessing Inner Radius: 0.0873 m; HasProtectiveEarth: TRUE; NominalHeight: 0; PowerFactor: 0; ConductorFunction: L1; NumberOfPoles: 0; TotalWattage: 0; ExpectedLife: N/A; WarrantyDurationParts: N/A; IP_Code: 0; ModelLabel: N/A; NumberOfSources: 0; ModelReference: N/A; Shape: N/A; NominalFrequencyRange: 0; WarrantyDescription: N/A; Constituents: N/A; AccessibilityPerformance: N/A; MaximumPlenumSensibleLoad: 0; RatedVoltage: 0; SustainabilityPerformance: N/A; Reference: REF TYPE MARK; SerialNumber: N/A; WarrantyStartDate: N/A; BackupSupplySystem: NO; TagNumber: N/A; AssetIdentifier: N/A; FixtureHeight: 0; InstallationDate: N/A; BarCode: N/A
Electrical - Loads - Apparent Load: 1076.39
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Name (M_Downlight - Recessed Can:SD - 213mm Diameter:SD - 213mm Diameter:...) | In | Schedule Level | Circuit Number | Panel | Host | Elevation (m)
748450 | 1C01 | Level: Level 1 | 22 | N21C1 | Linked Revit Model : Clinic_A.rvt | 2.68
748516 | 1C01 | Level: Level 1 | 22 | N21C1 | Linked Revit Model : Clinic_A.rvt | 2.68
748538 | 1C01 | Level: Level 1 | 22 | N21C1 | Linked Revit Model : Clinic_A.rvt | 2.68
748571 | 1C01 | Level: Level 1 | 22 | N21C1 | Linked Revit Model : Clinic_A.rvt | 2.68
749379 | 1AC2 | Level: Level 1 | 2 | L41C | <not associated> | 2.8
749526 | 1AC2 | Level: Level 1 | 2 | L41C | Linked Revit Model : Clinic_A.rvt | 2.68
749576 | 1AC2 | Level: Level 1 | 2 | L41C | Linked Revit Model : Clinic_A.rvt | 2.68
749654 | 1AC1 | Level: Level 1 | 2 | L41C | Linked Revit Model : Clinic_A.rvt | 3.8
749761 | 1AC1 | Level: Level 1 | 2 | L41C | Linked Revit Model : Clinic_A.rvt | 3.8
749805 | 1AC1 | Level: Level 1 | 2 | L41C | Linked Revit Model : Clinic_A.rvt | 3.8
749876 | 1AC1 | Level: Level 1 | 2 | L41C | Linked Revit Model : Clinic_A.rvt | 3.8
749899 | 1AC1 | Level: Level 1 | 2 | L41C | Linked Revit Model : Clinic_A.rvt | 3.8
749926 | 1AC1 | Level: Level 1 | 2 | L41C | Linked Revit Model : Clinic_A.rvt | 3.8
749997 | 1AC1 | Level: Level 1 | 2 | L41C | Linked Revit Model : Clinic_A.rvt | 3.8
750152 | 1AC1 | Level: Level 1 | 2 | L41B | Linked Revit Model : Clinic_A.rvt | 2.68
780754 | 2D10 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt | 2.68
780882 | 2D10 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt | 2.68
780905 | 2D10 | Level: Level 2 | 6 | L42B | Linked Revit Model : Clinic_A.rvt | 2.68
827108 | 1B19 | Level: Level 1 | 1 | L41B | Linked Revit Model : Clinic_A.rvt | 2.68
827428 | Level 1 | Level: Level 1 | 6 | L41B | Linked Revit Model : Clinic_A.rvt | 2.68
827488 | Level 1 | Level: Level 1 | 6 | L41B | Linked Revit Model : Clinic_A.rvt | 2.68

# IfcFlowTerminal: SDB - 213mm Diameter (6)
Type - ElementType: SDB - 213mm Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Photometrics - Dimming Lamp Color Temperature Shift: 0; Light Source Definition (family): Point+HemiSpherical; Color Filter: 16777215; Initial Intensity: 0; Initial Color: 0; Light Loss Factor: 0; Lumens: 1800
Constraints - Default Elevation: 1.2 m; Host: Linked Revit Model : Clinic_A.rvt
Electrical - Ballast Voltage: 1291.67; Ballast Number of Poles: 1; Lamp: T4, QUAD TUBE, CRI=82; Load Classification: Lighting - Dwelling Unit; Wattage Comments: 26
Electrical - Loads - Apparent Load: 1076.39
Dimensions - Recessing Height: 0.2 m; Light Source Symbol Size: 0.05 m; Recessing Diameter: 0.2 m
Identity Data - OmniClass Title: Downlights; OmniClass Number: 23.80.70.11.14.11; Description: SAME AS SD EXCEPT WITH EMERGENCY BATTERY PACK.; Assembly Code: D5020220; Manufacturer: N/A; Assembly Description: Lighting - Incandescent; Type Mark: SDB
Other - HasProtectiveEarth: TRUE; MaintenanceFactor: 0; TotalWattage: 0; NominalFrequencyRange: 0; CodePerformance: N/A; RatedCurrent: 0; WarrantyGuarantorParts: N/A; Shape: N/A; ReplacementCost: N/A; WarrantyDescription: N/A; WarrantyDurationLabor: N/A; NominalWidth: 0; ExpectedLife: N/A; NominalLength: 0; MaximumSpaceSensibleLoad: 0; Recessing Radius: 0.1 m; SensibleLoadToRadiant: 0; MaximumPlenumSensibleLoad: 0; Grade: N/A; Features: N/A; NominalHeight: 0; WarrantyDurationParts: N/A; Recessing Inner Radius: 0.0873 m; SustainabilityPerformance: N/A; NumberOfSources: 0; NumberOfPoles: 0; IP_Code: 0; ConductorFunction: L1; ModelReference: N/A; Material: N/A; ModelLabel: N/A; AccessibilityPerformance: N/A; WarrantyGuarantorLabor: N/A; ProductionYear: N/A; Constituents: N/A; Size: 0; PowerFactor: 0; RatedVoltage: 0; AssetAccountingType: FIXED; Reference: REF TYPE MARK; SerialNumber: N/A; BarCode: N/A; Schedule Level: Level: Level 1; AssetIdentifier: N/A; BackupSupplySystem: YES; InstallationDate: N/A; TagNumber: N/A; WarrantyStartDate: N/A; FixtureHeight: 0
Electrical - Lighting - Calculate Coefficient of Utilization: no
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Name (M_Downlight - Recessed Can:SDB - 213mm Diameter:SDB - 213mm Diameter:...) | In | Circuit Number | Panel | Elevation (m)
749482 | 1AC2 | 2 | L41C | 2.68
749727 | 1AC1 | 2 | L41C | 3.8
749843 | 1AC1 | 2 | L41C | 3.8
749954 | 1AC1 | 2 | L41C | 3.8
750055 | 1AC1 | 2 | L41B | 2.68
827479 | Level 1 | 6 | L41B | 2.68

# IfcFlowTerminal: SE - 213mm Diameter (6)
Type - ElementType: SE - 213mm Diameter; Classification: D5020220 Lighting - Incandescent (UniFormat)
Electrical - Loads - Apparent Load: 1076.39; Panel: L42B; Circuit Number: 6
Photometrics - Light Loss Factor: 0; Lumens: 1800; Initial Intensity: 0; Initial Color: 0; Light Source Definition (family): Point+HemiSpherical; Color Filter: 16777215; Dimming Lamp Color Temperature Shift: 0
Constraints - Default Elevation: 1.2 m
Electrical - Ballast Number of Poles: 1; Ballast Voltage: 1291.67; Lamp: T4, QUAD TUBE, CRI=82; Wattage Comments: 26; Load Classification: Lighting - Dwelling Unit
Identity Data - Manufacturer: N/A; OmniClass Title: Downlights; Assembly Code: D5020220; OmniClass Number: 23.80.70.11.14.11; Description: RECESSED COMPACT FLOURESCENT DOWNLIGHT WITH 213mm DIAMETER CEILING APERTURE, CLEAR SPECULAR REFLECTORS. DEPTH OF FIXTURE NOT TO EXCEED 152.4mm.; Type Mark: SE; Assembly Description: Lighting - Incandescent
Dimensions - Recessing Diameter: 0.2 m; Light Source Symbol Size: 0.05 m; Recessing Height: 0.2 m
Other - Recessing Inner Radius: 0.0873 m; Shape: N/A; ModelReference: N/A; Recessing Radius: 0.1 m; ModelLabel: N/A; PowerFactor: 0; ConductorFunction: L1; HasProtectiveEarth: TRUE; NumberOfPoles: 0; NominalFrequencyRange: 0; MaintenanceFactor: 0; ProductionYear: N/A; SustainabilityPerformance: N/A; WarrantyDurationParts: N/A; RatedCurrent: 0; WarrantyDurationLabor: N/A; RatedVoltage: 0; Features: N/A; TotalWattage: 0; Constituents: N/A; MaximumSpaceSensibleLoad: 0; SensibleLoadToRadiant: 0; AccessibilityPerformance: N/A; IP_Code: 0; WarrantyDescription: N/A; AssetAccountingType: FIXED; ReplacementCost: N/A; ExpectedLife: N/A; Material: N/A; WarrantyGuarantorParts: N/A; CodePerformance: N/A; WarrantyGuarantorLabor: N/A; NominalLength: 0; Size: 0; Grade: N/A; NominalHeight: 0; MaximumPlenumSensibleLoad: 0; NominalWidth: 0; NumberOfSources: 0; AssetIdentifier: N/A; WarrantyStartDate: N/A; SerialNumber: N/A; InstallationDate: N/A; TagNumber: N/A; FixtureHeight: 0; Schedule Level: Level: Level 2; BackupSupplySystem: NO; BarCode: N/A; Reference: REF TYPE MARK
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Name (M_Downlight - Recessed Can:SE - 213mm Diameter:SE - 213mm Diameter:...) | In | Host | Elevation (m)
780357 | 2D11 | Linked Revit Model : Clinic_A.rvt | 2.68
780417 | 2D11 | Linked Revit Model : Clinic_A.rvt | 2.68
780461 | 2D11 | Linked Revit Model : Clinic_A.rvt | 2.68
780518 | 2D11 | Linked Revit Model : Clinic_A.rvt | 2.68
780568 | 2D13 | <not associated> | 2.8
850647 | 2D12 | Linked Revit Model : Clinic_A.rvt | 2.68

# IfcFlowTerminal: Single Pole (232)
Type - ElementType: Single Pole; PredefinedType: USERDEFINED; Classification:  (UniFormat)
Electrical - Load Classification: Other; Switch Voltage: 1291.67
Constraints - Default Elevation: 1.2 m; Offset: 0 m; Elevation: 1.2 m
Electrical - Loads - Apparent Load: 0
Identity Data - OmniClass Number: 23.80.50.11.14; Manufacturer: N/A; OmniClass Title: Switches
Other - AssetAccountingType: FIXED; ConductorFunction: L1; ProductionYear: N/A; HasProtectiveEarth: TRUE; Grade: N/A; Constituents: N/A; AccessibilityPerformance: N/A; NominalFrequencyRange: 0; RatedCurrent: 0; NominalLength: 0; Material: N/A; WarrantyDurationParts: N/A; ReplacementCost: N/A; Features: N/A; CodePerformance: N/A; WarrantyDurationLabor: N/A; ExpectedLife: N/A; ModelReference: N/A; RatedVoltage: 0; NominalHeight: 0; WarrantyDescription: N/A; NumberOfPoles: 0; SustainabilityPerformance: N/A; WarrantyGuarantorParts: N/A; IP_Code: 0; ModelLabel: N/A; PowerFactor: 0; Size: 0; NominalWidth: 0; WarrantyGuarantorLabor: N/A; Shape: N/A; TagNumber: N/A; BarCode: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; AssetIdentifier: N/A; SerialNumber: N/A
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-0 VA
Name (M_Lighting Switches:Single Pole:Single Pole:...) | In | Schedule Level | Panel | Circuit Number | Host
795878 | 1C19 | Level: Level 1 | L41C | 4 | Linked Revit Model : Clinic_A.rvt
795927 | 1C16 | Level: Level 1 | L41C | 4 | Linked Revit Model : Clinic_A.rvt
796348 | 1C14 | Level: Level 1 | L41C | 4 | Linked Revit Model : Clinic_A.rvt
796984 | 1C12 | Level: Level 1 | L41C | 4 | Linked Revit Model : Clinic_A.rvt
797783 | 1C11 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
798440 | 1C15 | Level: Level 1 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt
798847 | 1C17 | Level: Level 1 | L41C | 4 | Linked Revit Model : Clinic_A.rvt
799439 | 1C13 | Level: Level 1 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt
799512 | 1D16 | Level: Level 1 | L41C | 5 | Linked Revit Model : Clinic_A.rvt
799568 | 1D17 | Level: Level 1 | L41C | 5 | Linked Revit Model : Clinic_A.rvt
800165 | 1D21 | Level: Level 1 | L41C | 5 | Linked Revit Model : Clinic_A.rvt
800467 | 1D20 | Level: Level 1 | L41C | 5 | Linked Revit Model : Clinic_A.rvt
800541 | 1D19 | Level: Level 1 | L41C | 5 | Linked Revit Model : Clinic_A.rvt
800786 | 1D15 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
801082 | 1D14 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
801247 | 1D12 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
801352 | 1D10 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
801519 | 1D08 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
801562 | 1D01 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
801956 | 1D02 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
802435 | 1D04 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
802702 | 1D05 | Level: Level 1 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt
802817 | 1D06 | Level: Level 1 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt
802982 | 1D07 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
803110 | 1D09 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
803163 | 1D11 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
803313 | 1D13 | Level: Level 1 | L41C | 3 | Linked Revit Model : Clinic_A.rvt
803418 | 1C02 | Level: Level 1 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt
803717 | 1C03 | Level: Level 1 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt
803770 | 1C10 | Level: Level 1 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt
804030 | 1C07 | Level: Level 1 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt
804075 | 1C07 | Level: Level 1 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt
804129 | 1C08 | Level: Level 1 | L41C | 9 | Linked Revit Model : Clinic_A.rvt
804666 | 1C09 | Level: Level 1 | L41C | 9 | Linked Revit Model : Clinic_A.rvt
804855 | 1C06 | Level: Level 1 | L41C | 9 | Linked Revit Model : Clinic_A.rvt
804939 | 1C05 | Level: Level 1 | L41C | 9 | Linked Revit Model : Clinic_A.rvt
805044 | 1C04 | Level: Level 1 | L41C | 9 | Linked Revit Model : Clinic_A.rvt
805222 | 1CC1 | Level: Level 1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt
805429 | 1A09 | Level: Level 1 | N21C1 | 23 | Linked Revit Model : Clinic_A.rvt
805499 | 1A12 | Level: Level 1 | N21C1 | 23 | Linked Revit Model : Clinic_A.rvt
805558 | 1AC4 | Level: Level 1 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt
805694 | 1A10 | Level: Level 1 | N21C1 | 23 | Orphaned
805799 | 1A11 | Level: Level 1 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt
805904 | 1A08 | Level: Level 1 | N21C1 | 23 | Linked Revit Model : Clinic_A.rvt
806115 | 1A16 | Level: Level 1 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt
806189 | 1A07 | Level: Level 1 | L41C | 1 | Linked Revit Model : Clinic_A.rvt
806381 | 1AC5 | Level: Level 1 | L41C | 1 | Linked Revit Model : Clinic_A.rvt
806465 | 1A05 | Level: Level 1 | L41C | 1 | Linked Revit Model : Clinic_A.rvt
806667 | 1A03 | Level: Level 1 | L41C | 1 | Orphaned
807125 | 1A06 | Level: Level 1 | L41C | 1 | Linked Revit Model : Clinic_A.rvt
807245 | 1A04 | Level: Level 1 | L41C | 1 | Linked Revit Model : Clinic_A.rvt
807422 | 1AC5 | Level: Level 1 | L41C | 1 | Linked Revit Model : Clinic_A.rvt
807734 | 1A15 | Level: Level 1 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt
808165 | 1A14 | Level: Level 1 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt
808334 | 1A13 | Level: Level 1 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt
808853 | 1DC4 | Level: Level 1 | L41C | 6 | Linked Revit Model : Clinic_A.rvt
809790 | 1D18 | Level: Level 1 | L41C | 5 | Linked Revit Model : Clinic_A.rvt
810587 | 1D22 | Level: Level 1 | L41C | 5 | Linked Revit Model : Clinic_A.rvt
810640 | 1D22 | Level: Level 1 | L41C | 5 | Linked Revit Model : Clinic_A.rvt
811985 | 1D23 | Level: Level 1 | L41B | 5 | Linked Revit Model : Clinic_A.rvt
812075 | 1D24 | Level: Level 1 | L41B | 5 | Linked Revit Model : Clinic_A.rvt
812252 | 1D27 | Level: Level 1 | L41B | 5 | Linked Revit Model : Clinic_A.rvt
812430 | 1D30 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
812618 | 1DC6 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
812766 | 1D26 | Level: Level 1 | L41B | 5 | Linked Revit Model : Clinic_A.rvt
812883 | 1D25 | Level: Level 1 | L41B | 5 | Linked Revit Model : Clinic_A.rvt
813009 | 1E14 | Level: Level 1 | L41B | 5 | Linked Revit Model : Clinic_A.rvt
813186 | 1E12 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
813301 | 1E33 | Level: Level 1 | L41B | 3 | Grid : 7
813365 | 1E15 | Level: Level 1 | L41B | 5 | Linked Revit Model : Clinic_A.rvt
813556 | 1E11 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
813945 | 1E09 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
814012 | 1E10 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
814134 | 1E07 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
814259 | 1E07 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
814350 | 1E06 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
814459 | 1E04 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
814607 | 1E01 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
814717 | 1E02 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
814814 | 1E03 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
814969 | 1E05 | Level: Level 1 | L41B | 3 | Linked Revit Model : Clinic_A.rvt
815105 | 1D38 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
815223 | 1B21 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
815581 | 1D40 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
816136 | 1D35 | Level: Level 1 | L41B | 4 | Orphaned
816486 | 1D36 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
816508 | 1D34 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
816706 | 1D32 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
816770 | 1D28 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
816853 | 1D31 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
817170 | 1D33 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
817233 | 1D39 | Level: Level 1 | L41B | 4 | Linked Revit Model : Clinic_A.rvt
817531 | 1DC1 | Level: Level 1 | L41C | 8 | Linked Revit Model : Clinic_A.rvt
817560 | 1E26 | Level: Level 1 | L41B | 7 | Linked Revit Model : Clinic_A.rvt
817668 | 1E27 | Level: Level 1 | L41B | 7 | Linked Revit Model : Clinic_A.rvt
817744 | 1E28 | Level: Level 1 | L41B | 7 | Linked Revit Model : Clinic_A.rvt
817900 | 1E24 | Level: Level 1 | L41B | 7 | Linked Revit Model : Clinic_A.rvt
818059 | 1E24 | Level: Level 1 | L41B | 7 | Linked Revit Model : Clinic_A.rvt
818499 | 1E20 | Level: Level 1 | L41B | 6 | Linked Revit Model : Clinic_A.rvt
818809 | 1E21 | Level: Level 1 | L41B | 6 | Linked Revit Model : Clinic_A.rvt
818986 | 1E22 | Level: Level 1 | L41B | 6 | Grid : 6.7
819190 | 1E30 | Level: Level 1 | L41B | 6 | Linked Revit Model : Clinic_A.rvt
819214 | 1EC4 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
819278 | 1E23 | Level: Level 1 | L41B | 6 | Grid : B
819445 | 1E19 | Level: Level 1 | L41B | 6 | Linked Revit Model : Clinic_A.rvt
819572 | 1E16 | Level: Level 1 | L41B | 6 | Linked Revit Model : Clinic_A.rvt
819825 | 1E18 | Level: Level 1 | L41B | 6 | Linked Revit Model : Clinic_A.rvt
819880 | 1E17 | Level: Level 1 | L41B | 6 | Linked Revit Model : Clinic_A.rvt
820075 | 1BC3 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
820512 | 1BC4 | Level: Level 1 | L41B | 2 | Linked Revit Model : Clinic_A.rvt
820830 | 1B23 | Level: Level 1 | L41B | 8 | Linked Revit Model : Clinic_A.rvt
821134 | 1B19 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
821262 | 1B19 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
821628 | 1B19 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
821969 | 1B09 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
821991 | 1B07 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
822076 | 1B05 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
822180 | 1B17 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
822413 | 1B04 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
822650 | 1B11 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
822735 | 1B10 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
823003 | 1B08 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
823066 | 1B06 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
823139 | 1B04 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
823724 | 1B02 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
824211 | 1BC1 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
824335 | 1B01 | Level: Level 1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt
826019 | 1C02 | Level: Level 1 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt
827675 | 2C16 | Level: Level 2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt
827714 | 2C14 | Level: Level 2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt
827828 | 2C13 | Level: Level 2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt
828216 | 2C17 | Level: Level 2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt
828563 | 2CC5 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
828798 | 2C15 | Level: Level 2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt
828923 | 2CC5 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
829157 | 2C11 | Level: Level 2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt
829252 | 2C12 | Level: Level 2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt
829306 | 2CC4 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
829485 | 2C09 | Level: Level 2 | L42C | 5 | Linked Revit Model : Clinic_A.rvt
829579 | 2C10 | Level: Level 2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt
829725 | 2C06 | Level: Level 2 | L42C | 5 | Linked Revit Model : Clinic_A.rvt
829849 | 2C08 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
830041 | 2C07 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
830178 | 2C05 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
830345 | 2C04 | Level: Level 2 | L42C | 4 | Linked Revit Model : Clinic_A.rvt
830500 | 2C02 | Level: Level 2 | L42C | 4 | Linked Revit Model : Clinic_A.rvt
830604 | 2C03 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
830657 | 2C01 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
830720 | 2A09 | Level: Level 2 | L42C | 4 | Linked Revit Model : Clinic_A.rvt
830949 | 2AC2 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
830993 | 2A10 | Level: Level 2 | L42C | 7 | Linked Revit Model : Clinic_A.rvt
831048 | 2A11 | Level: Level 2 | L42C | 7 | Grid : F
831153 | 2A08 | Level: Level 2 | L42C | 4 | Linked Revit Model : Clinic_A.rvt
831258 | 2A07 | Level: Level 2 | L42C | 8 | Linked Revit Model : Clinic_A.rvt
831311 | 2A06 | Level: Level 2 | L42C | 8 | Linked Revit Model : Clinic_A.rvt
831395 | 2A05 | Level: Level 2 | L42C | 8 | Linked Revit Model : Clinic_A.rvt
831529 | 2A13 | Level: Level 2 | L42C | 7 | Linked Revit Model : Clinic_A.rvt
831649 | 2A03 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
831788 | 2A12 | Level: Level 2 | L42C | 7 | Grid : F
832546 | 2A04 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
832876 | 2A02 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
833311 | 2A14 | Level: Level 2 | L42C | 7 | Linked Revit Model : Clinic_A.rvt
833594 | 2A01 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
833917 | 2A11 | Level: Level 2 | L42C | 7 | Linked Revit Model : Clinic_A.rvt
834262 | Level 2 | Level: Level 2 | L42C | 3 | Grid : E.3
834510 | 2AC2 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
834624 | 2C24 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
834824 | 2C23 | Level: Level 2 | L42C | 2 | Grid : E.3
834867 | 2C22 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
835627 | 2C08 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
835701 | 2C07 | Level: Level 2 | L42C | 2 | Linked Revit Model : Clinic_A.rvt
835745 | 2C19 | Level: Level 2 | L42C | 2 | Grid : 6
836019 | 2DC2 | Level: Level 2 | L42B | 4 | Grid : D.9
836895 | 2CC1 | Level: Level 2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt
837031 | 2C18 | Level: Level 2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt
837305 | 2D05 | Level: Level 2 | L42C | 9 | Grid : 6
838010 | 2D09 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
838503 | 2D08 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
838833 | 2D07 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
839210 | 2D06 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
839646 | 2D06 | Level: Level 2 | L42B | 6 | Grid : 6
839952 | 2D18 | Level: Level 2 | L42B | 5 | Linked Revit Model : Clinic_A.rvt
840056 | 2D04-A | Level: Level 2 | L42B | 2 | Linked Revit Model : Clinic_A.rvt
840265 | 2D04 | Level: Level 2 | L42B | 2 | Linked Revit Model : Clinic_A.rvt
840473 | 2D02 | Level: Level 2 | L42B | 2 | Linked Revit Model : Clinic_A.rvt
840501 | 2D01 | Level: Level 2 | L42B | 2 | Linked Revit Model : Clinic_A.rvt
840574 | 2BC1 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
840967 | 2BC6 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
841093 | 2BC6 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
841296 | 2BC5 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
841350 | 2B7 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
841615 | 2B9 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
841678 | 2B4 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
841939 | 2B3 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
842128 | 2B2 | Level: Level 2 | L42B | 1 | <not associated>
843118 | 2B01 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
843150 | 2BC5 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
843258 | 2BC4 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
843352 | 2B5 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
843519 | 2B25 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
843727 | 2B24 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
843801 | 2B23 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
843886 | 2B19 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
843939 | 2B17 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
844003 | 2B15 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
844160 | 2B14 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
844253 | 2B13 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
844413 | 2B12 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
844548 | 2B10 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
844674 | 2B8 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
844781 | 2B6 | Level: Level 2 | L42B | 3 | Linked Revit Model : Clinic_A.rvt
844874 | 2B22 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
845255 | 2B21 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
845507 | 2B20 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
845612 | 2B18 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
845761 | 2B16 | Level: Level 2 | L42B | 1 | Linked Revit Model : Clinic_A.rvt
845878 | 2BC3 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
846291 | 2BC2 | Level: Level 2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt
846331 | 2D20 | Level: Level 2 | L42B | 7 | Linked Revit Model : Clinic_A.rvt
846589 | 2D20 | Level: Level 2 | L42B | 7 | Linked Revit Model : Clinic_A.rvt
846652 | 2D19 | Level: Level 2 | L42B | 6 | Orphaned
846829 | 2D17 | Level: Level 2 | L42B | 6 | Orphaned
846902 | 2D14 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
847049 | 2D15 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
847471 | 2D16 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
847584 | 2D13 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
847690 | 2D12 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
848624 | 2D11 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
848806 | 2D10 | Level: Level 2 | L42B | 6 | Linked Revit Model : Clinic_A.rvt
850233 | 2A01 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
850240 | 2A01 | Level: Level 2 | L42C | 6 | Linked Revit Model : Clinic_A.rvt
850424 | 2D18 | Level: Level 2 | L42B | 5 | Linked Revit Model : Clinic_A.rvt

# IfcFlowTerminal: Standard (958)
Type - ElementType: Standard; PredefinedType: POWEROUTLET; Classification:  (UniFormat)
Constraints - Default Elevation: 0.46 m; Offset: 0 m
Electrical - Switch Voltage: 1291.67; Load Classification: Receptacle; Load: 1937.5
Identity Data - OmniClass Title: Ground Fault Receptacles; OmniClass Number: 23.80.50.11.17; Manufacturer: N/A
Other - WarrantyDescription: N/A; WarrantyDurationLabor: N/A; HasProtectiveEarth: TRUE; WarrantyGuarantorLabor: N/A; PowerFactor: 0; ExpectedLife: N/A; ProductionYear: N/A; Constituents: N/A; WarrantyDurationParts: N/A; RatedCurrent: 0; IsPluggableOutlet: TRUE; ReplacementCost: N/A; WarrantyGuarantorParts: N/A; Shape: N/A; NominalFrequencyRange: 0; ConductorFunction: L1; RatedVoltage: 0; Features: N/A; IP_Code: 0; AssetAccountingType: FIXED; Material: N/A; AccessibilityPerformance: N/A; SustainabilityPerformance: N/A; ModelReference: N/A; NominalLength: 0; NominalWidth: 0; CodePerformance: N/A; ModelLabel: N/A; NumberOfPoles: 0; Grade: N/A; Size: 0; NominalHeight: 0; AssetIdentifier: N/A; WarrantyStartDate: N/A; BarCode: N/A; SerialNumber: N/A; TagNumber: N/A; InstallationDate: N/A
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-180 VA
Name (M_Duplex Receptacle:Standard:Standard:...) | In | Schedule Level | Elevation (m) | Host | Circuit Number | Panel | Mark
861697 | 1C19 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21C | 1
861782 | 1C19 | Level: Level 1 | 0.5 | M_Lighting Switches : Single Pole | 3 | N21C | 2
861908 | 1C19 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21C | 3
861952 | 1C19 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 3 | N21C | 4
862253 | 1C16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21C | 5
862376 | 1C16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21C | 6
862523 | 1C16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21C | 8
862576 | 1C16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21C | 9
862619 | 1C16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21C | 10
862692 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21C | 11
862756 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 5 | N21C | 12
862830 | 1C14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 1 | N21C | 13
863260 | 1C14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21C | 14
863323 | 1C14 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21C | 15
863378 | 1C12 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21C | 16
863494 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21C | 17
863898 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21C | 18
863934 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21C | 19
863977 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 11 | N21C | 20
864020 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21C | 21
864443 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21C | 22
864497 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 6 | N21C | 23
864724 | 1C15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21C | 24
864777 | 1C15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21C | 25
864821 | 1C15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 9 | N21C | 26
864897 | 1C15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21C | 27
864952 | 1C15 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 7 | N21C | 28
864995 | 1D16 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 13 | N21C1 | 29
865195 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21C | 30
865424 | 1C18 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21C | 31
865467 | 1CC3 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 4 | N21C | 32
865521 | 1C11 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 22 | N21C | 33
865693 | Level 1 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 2 | N21C | 34
866007 | 1C09 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21C | 35
866278 | 1C09 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21C | 36
866341 | 1C09 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21C | 37
866385 | 1C09 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21C | 38
866448 | 1C09 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21C | 39
866511 | 1C09 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21C | 40
866565 | 1C09 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21C | 41
866628 | 1C06 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21C | 42
866723 | 1C05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 12 | N21C | 43
866767 | 1C05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21C | 44
866821 | 1C05 | Level: Level 1 | 0.5 | Grid : 5 | 15 | N21C | 45
866865 | 1C05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21C | 46
867031 | 1C05 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21C | 47
867075 | 1C04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 15 | N21C | 48
867200 | 1C04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21C | 49
867254 | 1C04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21C | 50
867328 | 1CC2 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21C | 51
867383 | 1C08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21C | 52
867456 | 1C08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21C | 53
867500 | 1C08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 8 | N21C | 54
867563 | 1C04 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 16 | N21C | 55
867689 | 1C08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C | 56
867854 | 1C08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 17 | N21C | 57
867949 | 1C08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C | 58
868055 | 1C08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C | 59
868098 | 1C08 | Level: Level 1 | 0.5 | Linked Revit Model : Clinic_A.rvt | 10 | N21C | 60
